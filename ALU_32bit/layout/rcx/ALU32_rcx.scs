    I_MXI0_I560_MP18 (XI0_I560_xp1 XI0_I560_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I560_MP20 (I0_pp1_2 I0_B_3_b3_0 XI0_I560_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I560_MP19 (XI0_I560_xp1 XI0_I560_xan I0_pp1_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I560_MP17 (VDD XI0_I560_xn XI0_I560_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I560_MP6 (XI0_I560_p1 I0_A_2_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I560_MP8 (XI0_I560_xn I0_A_1_b3_0 XI0_I560_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I560_MP7 (XI0_I560_p1 I0_two1_b3_0 XI0_I560_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I560_MP5 (VDD I0_one1_b3_0 XI0_I560_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I560_MP10 (XI0_I560_xan XI0_I560_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I834_MP12 (VDD I0_B_13_b3_0 XI0_I834_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I834_MP18 (XI0_I834_xp1 XI0_I834_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I834_MP20 (I0_pp6_1 I0_B_13_b3_0 XI0_I834_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I834_MP19 (XI0_I834_xp1 XI0_I834_xan I0_pp6_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I834_MP17 (VDD XI0_I834_xn XI0_I834_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I834_MP6 (XI0_I834_p1 I0_A_1_b3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I834_MP8 (XI0_I834_xn I0_A_0_b3_2 XI0_I834_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I834_MP7 (XI0_I834_p1 I0_two6_b3_0 XI0_I834_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I834_MP5 (VDD I0_one6_b3_0 XI0_I834_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I834_MP10 (XI0_I834_xan XI0_I834_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1063_MP12 (VDD I0_B_21_b3_1 XI0_I1063_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1063_MP18 (XI0_I1063_xp1 XI0_I1063_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1063_MP20 (I0_pp10_10 I0_B_21_b3_1 XI0_I1063_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1063_MP19 (XI0_I1063_xp1 XI0_I1063_xan I0_pp10_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1063_MP17 (VDD XI0_I1063_xn XI0_I1063_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1063_MP6 (XI0_I1063_p1 I0_A_10_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1063_MP8 (XI0_I1063_xn I0_A_9_b3_3 XI0_I1063_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1063_MP7 (XI0_I1063_p1 I0_two10_b3_1 XI0_I1063_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1063_MP5 (VDD I0_one10_b3_1 XI0_I1063_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1063_MP10 (XI0_I1063_xan XI0_I1063_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1009_MP12 (VDD I0_B_19_b3_2 XI0_I1009_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1009_MP18 (XI0_I1009_xp1 XI0_I1009_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1009_MP20 (I0_pp9_11 I0_B_19_b3_2 XI0_I1009_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1009_MP19 (XI0_I1009_xp1 XI0_I1009_xan I0_pp9_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1009_MP17 (VDD XI0_I1009_xn XI0_I1009_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1009_MP6 (XI0_I1009_p1 I0_A_11_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1009_MP8 (XI0_I1009_xn I0_A_10_b3_3 XI0_I1009_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1009_MP7 (XI0_I1009_p1 I0_two9_b3_2 XI0_I1009_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1009_MP5 (VDD I0_one9_b3_2 XI0_I1009_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1009_MP10 (XI0_I1009_xan XI0_I1009_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1010_MP12 (VDD I0_B_19_b3_2 XI0_I1010_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1010_MP18 (XI0_I1010_xp1 XI0_I1010_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1010_MP20 (I0_pp9_12 I0_B_19_b3_2 XI0_I1010_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1010_MP19 (XI0_I1010_xp1 XI0_I1010_xan I0_pp9_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1010_MP17 (VDD XI0_I1010_xn XI0_I1010_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1010_MP6 (XI0_I1010_p1 I0_A_12_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1010_MP8 (XI0_I1010_xn I0_A_11_b3_3 XI0_I1010_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1010_MP7 (XI0_I1010_p1 I0_two9_b3_2 XI0_I1010_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1010_MP5 (VDD I0_one9_b3_2 XI0_I1010_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1010_MP10 (XI0_I1010_xan XI0_I1010_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I954_MP12 (VDD I0_B_17_b3_2 XI0_I954_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I954_MP18 (XI0_I954_xp1 XI0_I954_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I954_MP20 (I0_pp8_11 I0_B_17_b3_2 XI0_I954_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I954_MP19 (XI0_I954_xp1 XI0_I954_xan I0_pp8_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I954_MP17 (VDD XI0_I954_xn XI0_I954_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I954_MP6 (XI0_I954_p1 I0_A_11_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I954_MP8 (XI0_I954_xn I0_A_10_b3_3 XI0_I954_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I954_MP7 (XI0_I954_p1 I0_two8_b3_2 XI0_I954_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I954_MP5 (VDD I0_one8_b3_2 XI0_I954_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I954_MP10 (XI0_I954_xan XI0_I954_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I956_MP12 (VDD I0_B_17_b3_2 XI0_I956_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I956_MP18 (XI0_I956_xp1 XI0_I956_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I956_MP20 (I0_pp8_13 I0_B_17_b3_2 XI0_I956_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I956_MP19 (XI0_I956_xp1 XI0_I956_xan I0_pp8_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I956_MP17 (VDD XI0_I956_xn XI0_I956_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I956_MP6 (XI0_I956_p1 I0_A_13_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I956_MP8 (XI0_I956_xn I0_A_12_b3_3 XI0_I956_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I956_MP7 (XI0_I956_p1 I0_two8_b3_2 XI0_I956_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I956_MP5 (VDD I0_one8_b3_2 XI0_I956_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I956_MP10 (XI0_I956_xan XI0_I956_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1011_MP12 (VDD I0_B_19_b3_2 XI0_I1011_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1011_MP18 (XI0_I1011_xp1 XI0_I1011_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1011_MP20 (I0_pp9_13 I0_B_19_b3_2 XI0_I1011_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1011_MP19 (XI0_I1011_xp1 XI0_I1011_xan I0_pp9_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1011_MP17 (VDD XI0_I1011_xn XI0_I1011_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1011_MP6 (XI0_I1011_p1 I0_A_13_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1011_MP8 (XI0_I1011_xn I0_A_12_b3_3 XI0_I1011_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1011_MP7 (XI0_I1011_p1 I0_two9_b3_2 XI0_I1011_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1011_MP5 (VDD I0_one9_b3_2 XI0_I1011_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1011_MP10 (XI0_I1011_xan XI0_I1011_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I959_MP12 (VDD I0_B_17_b3_2 XI0_I959_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I959_MP18 (XI0_I959_xp1 XI0_I959_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I959_MP20 (I0_pp8_16 I0_B_17_b3_2 XI0_I959_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I959_MP19 (XI0_I959_xp1 XI0_I959_xan I0_pp8_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I959_MP17 (VDD XI0_I959_xn XI0_I959_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I959_MP6 (XI0_I959_p1 I0_A_16_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I959_MP8 (XI0_I959_xn I0_A_15_b3_3 XI0_I959_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I959_MP7 (XI0_I959_p1 I0_two8_b3_2 XI0_I959_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I959_MP5 (VDD I0_one8_b3_2 XI0_I959_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I959_MP10 (XI0_I959_xan XI0_I959_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1012_MP12 (VDD I0_B_19_b3_2 XI0_I1012_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1012_MP18 (XI0_I1012_xp1 XI0_I1012_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1012_MP20 (I0_pp9_14 I0_B_19_b3_2 XI0_I1012_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1012_MP19 (XI0_I1012_xp1 XI0_I1012_xan I0_pp9_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1012_MP17 (VDD XI0_I1012_xn XI0_I1012_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1012_MP6 (XI0_I1012_p1 I0_A_14_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1012_MP8 (XI0_I1012_xn I0_A_13_b3_3 XI0_I1012_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1012_MP7 (XI0_I1012_p1 I0_two9_b3_2 XI0_I1012_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1012_MP5 (VDD I0_one9_b3_2 XI0_I1012_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1012_MP10 (XI0_I1012_xan XI0_I1012_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1014_MP12 (VDD I0_B_19_b3_2 XI0_I1014_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1014_MP18 (XI0_I1014_xp1 XI0_I1014_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1014_MP20 (I0_pp9_16 I0_B_19_b3_2 XI0_I1014_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1014_MP19 (XI0_I1014_xp1 XI0_I1014_xan I0_pp9_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1014_MP17 (VDD XI0_I1014_xn XI0_I1014_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1014_MP6 (XI0_I1014_p1 I0_A_16_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1014_MP8 (XI0_I1014_xn I0_A_15_b3_3 XI0_I1014_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1014_MP7 (XI0_I1014_p1 I0_two9_b3_2 XI0_I1014_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1014_MP5 (VDD I0_one9_b3_2 XI0_I1014_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1014_MP10 (XI0_I1014_xan XI0_I1014_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1066_MP12 (VDD I0_B_21_b3_2 XI0_I1066_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1066_MP18 (XI0_I1066_xp1 XI0_I1066_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1066_MP20 (I0_pp10_13 I0_B_21_b3_2 XI0_I1066_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1066_MP19 (XI0_I1066_xp1 XI0_I1066_xan I0_pp10_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1066_MP17 (VDD XI0_I1066_xn XI0_I1066_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1066_MP6 (XI0_I1066_p1 I0_A_13_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1066_MP8 (XI0_I1066_xn I0_A_12_b3_3 XI0_I1066_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1066_MP7 (XI0_I1066_p1 I0_two10_b3_2 XI0_I1066_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1066_MP5 (VDD I0_one10_b3_2 XI0_I1066_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1066_MP10 (XI0_I1066_xan XI0_I1066_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1067_MP12 (VDD I0_B_21_b3_2 XI0_I1067_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1067_MP18 (XI0_I1067_xp1 XI0_I1067_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1067_MP20 (I0_pp10_14 I0_B_21_b3_2 XI0_I1067_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1067_MP19 (XI0_I1067_xp1 XI0_I1067_xan I0_pp10_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1067_MP17 (VDD XI0_I1067_xn XI0_I1067_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1067_MP6 (XI0_I1067_p1 I0_A_14_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1067_MP8 (XI0_I1067_xn I0_A_13_b3_3 XI0_I1067_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1067_MP7 (XI0_I1067_p1 I0_two10_b3_2 XI0_I1067_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1067_MP5 (VDD I0_one10_b3_2 XI0_I1067_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1067_MP10 (XI0_I1067_xan XI0_I1067_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1069_MP12 (VDD I0_B_21_b3_2 XI0_I1069_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1069_MP18 (XI0_I1069_xp1 XI0_I1069_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1069_MP20 (I0_pp10_16 I0_B_21_b3_2 XI0_I1069_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1069_MP19 (XI0_I1069_xp1 XI0_I1069_xan I0_pp10_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1069_MP17 (VDD XI0_I1069_xn XI0_I1069_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1069_MP6 (XI0_I1069_p1 I0_A_16_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1069_MP8 (XI0_I1069_xn I0_A_15_b3_3 XI0_I1069_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1069_MP7 (XI0_I1069_p1 I0_two10_b3_2 XI0_I1069_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1069_MP5 (VDD I0_one10_b3_2 XI0_I1069_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1069_MP10 (XI0_I1069_xan XI0_I1069_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1068_MP12 (VDD I0_B_21_b3_2 XI0_I1068_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1068_MP18 (XI0_I1068_xp1 XI0_I1068_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1068_MP20 (I0_pp10_15 I0_B_21_b3_2 XI0_I1068_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1068_MP19 (XI0_I1068_xp1 XI0_I1068_xan I0_pp10_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1068_MP17 (VDD XI0_I1068_xn XI0_I1068_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1068_MP6 (XI0_I1068_p1 I0_A_15_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1068_MP8 (XI0_I1068_xn I0_A_14_b3_3 XI0_I1068_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1068_MP7 (XI0_I1068_p1 I0_two10_b3_2 XI0_I1068_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1068_MP5 (VDD I0_one10_b3_2 XI0_I1068_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1068_MP10 (XI0_I1068_xan XI0_I1068_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I962_MP12 (VDD I0_B_17_b3_3 XI0_I962_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I962_MP18 (XI0_I962_xp1 XI0_I962_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I962_MP20 (I0_pp8_19 I0_B_17_b3_3 XI0_I962_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I962_MP19 (XI0_I962_xp1 XI0_I962_xan I0_pp8_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I962_MP17 (VDD XI0_I962_xn XI0_I962_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I962_MP6 (XI0_I962_p1 I0_A_19_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I962_MP8 (XI0_I962_xn I0_A_18_b3_3 XI0_I962_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I962_MP7 (XI0_I962_p1 I0_two8_b3_3 XI0_I962_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I962_MP5 (VDD I0_one8_b3_3 XI0_I962_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I962_MP10 (XI0_I962_xan XI0_I962_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I960_MP12 (VDD I0_B_17_b3_3 XI0_I960_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I960_MP18 (XI0_I960_xp1 XI0_I960_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I960_MP20 (I0_pp8_17 I0_B_17_b3_3 XI0_I960_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I960_MP19 (XI0_I960_xp1 XI0_I960_xan I0_pp8_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I960_MP17 (VDD XI0_I960_xn XI0_I960_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I960_MP6 (XI0_I960_p1 I0_A_17_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I960_MP8 (XI0_I960_xn I0_A_16_b3_3 XI0_I960_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I960_MP7 (XI0_I960_p1 I0_two8_b3_3 XI0_I960_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I960_MP5 (VDD I0_one8_b3_3 XI0_I960_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I960_MP10 (XI0_I960_xan XI0_I960_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1015_MP12 (VDD I0_B_19_b3_3 XI0_I1015_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1015_MP18 (XI0_I1015_xp1 XI0_I1015_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1015_MP20 (I0_pp9_17 I0_B_19_b3_3 XI0_I1015_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1015_MP19 (XI0_I1015_xp1 XI0_I1015_xan I0_pp9_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1015_MP17 (VDD XI0_I1015_xn XI0_I1015_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1015_MP6 (XI0_I1015_p1 I0_A_17_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1015_MP8 (XI0_I1015_xn I0_A_16_b3_3 XI0_I1015_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1015_MP7 (XI0_I1015_p1 I0_two9_b3_3 XI0_I1015_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1015_MP5 (VDD I0_one9_b3_3 XI0_I1015_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1015_MP10 (XI0_I1015_xan XI0_I1015_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1017_MP12 (VDD I0_B_19_b3_3 XI0_I1017_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1017_MP18 (XI0_I1017_xp1 XI0_I1017_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1017_MP20 (I0_pp9_19 I0_B_19_b3_3 XI0_I1017_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1017_MP19 (XI0_I1017_xp1 XI0_I1017_xan I0_pp9_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1017_MP17 (VDD XI0_I1017_xn XI0_I1017_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1017_MP6 (XI0_I1017_p1 I0_A_19_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1017_MP8 (XI0_I1017_xn I0_A_18_b3_3 XI0_I1017_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1017_MP7 (XI0_I1017_p1 I0_two9_b3_3 XI0_I1017_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1017_MP5 (VDD I0_one9_b3_3 XI0_I1017_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1017_MP10 (XI0_I1017_xan XI0_I1017_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I505_MP12 (VDD I0_B_1_b3_0 XI0_I505_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I505_MP18 (XI0_I505_xp1 XI0_I505_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I505_MP20 (I0_pp0_2 I0_B_1_b3_0 XI0_I505_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I505_MP19 (XI0_I505_xp1 XI0_I505_xan I0_pp0_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I505_MP17 (VDD XI0_I505_xn XI0_I505_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I505_MP6 (XI0_I505_p1 I0_A_2_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I505_MP8 (XI0_I505_xn I0_A_1_b3_0 XI0_I505_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I505_MP7 (XI0_I505_p1 I0_two0_b3_0 XI0_I505_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I505_MP5 (VDD I0_one0_b3_0 XI0_I505_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I505_MP10 (XI0_I505_xan XI0_I505_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I559_MP12 (VDD I0_B_3_b3_0 XI0_I559_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I559_MP18 (XI0_I559_xp1 XI0_I559_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I559_MP20 (I0_pp1_1 I0_B_3_b3_0 XI0_I559_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I559_MP19 (XI0_I559_xp1 XI0_I559_xan I0_pp1_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I559_MP17 (VDD XI0_I559_xn XI0_I559_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I559_MP6 (XI0_I559_p1 I0_A_1_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I559_MP8 (XI0_I559_xn I0_A_0_b3_0 XI0_I559_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I559_MP7 (XI0_I559_p1 I0_two1_b3_0 XI0_I559_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I559_MP5 (VDD I0_one1_b3_0 XI0_I559_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I559_MP10 (XI0_I559_xan XI0_I559_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I558_MP12 (VDD I0_B_3_b3_0 XI0_I558_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I558_MP18 (XI0_I558_xp1 XI0_I558_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I558_MP20 (I0_pp1_0 I0_B_3_b3_0 XI0_I558_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I558_MP19 (XI0_I558_xp1 XI0_I558_xan I0_pp1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I558_MP17 (VDD XI0_I558_xn XI0_I558_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I558_MP6 (XI0_I558_p1 I0_A_0_b3_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I558_MP8 (XI0_I558_xn VSS XI0_I558_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I558_MP7 (XI0_I558_p1 I0_two1_b3_0 XI0_I558_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I558_MP5 (VDD I0_one1_b3_0 XI0_I558_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I558_MP10 (XI0_I558_xan XI0_I558_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1008_MP12 (VDD I0_B_19_b3_1 XI0_I1008_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1008_MP18 (XI0_I1008_xp1 XI0_I1008_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1008_MP20 (I0_pp9_10 I0_B_19_b3_1 XI0_I1008_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1008_MP19 (XI0_I1008_xp1 XI0_I1008_xan I0_pp9_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1008_MP17 (VDD XI0_I1008_xn XI0_I1008_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1008_MP6 (XI0_I1008_p1 I0_A_10_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1008_MP8 (XI0_I1008_xn I0_A_9_b3_3 XI0_I1008_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1008_MP7 (XI0_I1008_p1 I0_two9_b3_1 XI0_I1008_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1008_MP5 (VDD I0_one9_b3_1 XI0_I1008_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1008_MP10 (XI0_I1008_xan XI0_I1008_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I953_MP12 (VDD I0_B_17_b3_1 XI0_I953_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I953_MP18 (XI0_I953_xp1 XI0_I953_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I953_MP20 (I0_pp8_10 I0_B_17_b3_1 XI0_I953_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I953_MP19 (XI0_I953_xp1 XI0_I953_xan I0_pp8_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I953_MP17 (VDD XI0_I953_xn XI0_I953_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I953_MP6 (XI0_I953_p1 I0_A_10_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I953_MP8 (XI0_I953_xn I0_A_9_b3_3 XI0_I953_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I953_MP7 (XI0_I953_p1 I0_two8_b3_1 XI0_I953_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I953_MP5 (VDD I0_one8_b3_1 XI0_I953_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I953_MP10 (XI0_I953_xan XI0_I953_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I952_MP12 (VDD I0_B_17_b3_1 XI0_I952_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I952_MP18 (XI0_I952_xp1 XI0_I952_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I952_MP20 (I0_pp8_9 I0_B_17_b3_1 XI0_I952_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I952_MP19 (XI0_I952_xp1 XI0_I952_xan I0_pp8_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I952_MP17 (VDD XI0_I952_xn XI0_I952_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I952_MP6 (XI0_I952_p1 I0_A_9_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I952_MP8 (XI0_I952_xn I0_A_8_b3_3 XI0_I952_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I952_MP7 (XI0_I952_p1 I0_two8_b3_1 XI0_I952_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I952_MP5 (VDD I0_one8_b3_1 XI0_I952_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I952_MP10 (XI0_I952_xan XI0_I952_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1006_MP12 (VDD I0_B_19_b3_1 XI0_I1006_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1006_MP18 (XI0_I1006_xp1 XI0_I1006_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1006_MP20 (I0_pp9_8 I0_B_19_b3_1 XI0_I1006_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1006_MP19 (XI0_I1006_xp1 XI0_I1006_xan I0_pp9_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1006_MP17 (VDD XI0_I1006_xn XI0_I1006_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1006_MP6 (XI0_I1006_p1 I0_A_8_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1006_MP8 (XI0_I1006_xn I0_A_7_b3_3 XI0_I1006_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1006_MP7 (XI0_I1006_p1 I0_two9_b3_1 XI0_I1006_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1006_MP5 (VDD I0_one9_b3_1 XI0_I1006_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1006_MP10 (XI0_I1006_xan XI0_I1006_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1061_MP12 (VDD I0_B_21_b3_1 XI0_I1061_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1061_MP18 (XI0_I1061_xp1 XI0_I1061_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1061_MP20 (I0_pp10_8 I0_B_21_b3_1 XI0_I1061_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1061_MP19 (XI0_I1061_xp1 XI0_I1061_xan I0_pp10_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1061_MP17 (VDD XI0_I1061_xn XI0_I1061_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1061_MP6 (XI0_I1061_p1 I0_A_8_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1061_MP8 (XI0_I1061_xn I0_A_7_b3_3 XI0_I1061_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1061_MP7 (XI0_I1061_p1 I0_two10_b3_1 XI0_I1061_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1061_MP5 (VDD I0_one10_b3_1 XI0_I1061_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1061_MP10 (XI0_I1061_xan XI0_I1061_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1062_MP12 (VDD I0_B_21_b3_1 XI0_I1062_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1062_MP18 (XI0_I1062_xp1 XI0_I1062_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1062_MP20 (I0_pp10_9 I0_B_21_b3_1 XI0_I1062_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1062_MP19 (XI0_I1062_xp1 XI0_I1062_xan I0_pp10_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1062_MP17 (VDD XI0_I1062_xn XI0_I1062_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1062_MP6 (XI0_I1062_p1 I0_A_9_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1062_MP8 (XI0_I1062_xn I0_A_8_b3_3 XI0_I1062_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1062_MP7 (XI0_I1062_p1 I0_two10_b3_1 XI0_I1062_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1062_MP5 (VDD I0_one10_b3_1 XI0_I1062_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1062_MP10 (XI0_I1062_xan XI0_I1062_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1064_MP12 (VDD I0_B_21_b3_2 XI0_I1064_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1064_MP18 (XI0_I1064_xp1 XI0_I1064_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1064_MP20 (I0_pp10_11 I0_B_21_b3_2 XI0_I1064_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1064_MP19 (XI0_I1064_xp1 XI0_I1064_xan I0_pp10_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1064_MP17 (VDD XI0_I1064_xn XI0_I1064_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1064_MP6 (XI0_I1064_p1 I0_A_11_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1064_MP8 (XI0_I1064_xn I0_A_10_b3_3 XI0_I1064_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1064_MP7 (XI0_I1064_p1 I0_two10_b3_2 XI0_I1064_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1064_MP5 (VDD I0_one10_b3_2 XI0_I1064_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1064_MP10 (XI0_I1064_xan XI0_I1064_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1065_MP12 (VDD I0_B_21_b3_2 XI0_I1065_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1065_MP18 (XI0_I1065_xp1 XI0_I1065_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1065_MP20 (I0_pp10_12 I0_B_21_b3_2 XI0_I1065_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1065_MP19 (XI0_I1065_xp1 XI0_I1065_xan I0_pp10_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1065_MP17 (VDD XI0_I1065_xn XI0_I1065_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1065_MP6 (XI0_I1065_p1 I0_A_12_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1065_MP8 (XI0_I1065_xn I0_A_11_b3_3 XI0_I1065_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1065_MP7 (XI0_I1065_p1 I0_two10_b3_2 XI0_I1065_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1065_MP5 (VDD I0_one10_b3_2 XI0_I1065_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1065_MP10 (XI0_I1065_xan XI0_I1065_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I963_MP12 (VDD I0_B_17_b3_3 XI0_I963_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I963_MP18 (XI0_I963_xp1 XI0_I963_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I963_MP20 (I0_pp8_20 I0_B_17_b3_3 XI0_I963_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I963_MP19 (XI0_I963_xp1 XI0_I963_xan I0_pp8_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I963_MP17 (VDD XI0_I963_xn XI0_I963_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I963_MP6 (XI0_I963_p1 I0_A_20_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I963_MP8 (XI0_I963_xn I0_A_19_b3_3 XI0_I963_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I963_MP7 (XI0_I963_p1 I0_two8_b3_3 XI0_I963_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I963_MP5 (VDD I0_one8_b3_3 XI0_I963_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I963_MP10 (XI0_I963_xan XI0_I963_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I964_MP12 (VDD I0_B_17_b3_3 XI0_I964_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I964_MP18 (XI0_I964_xp1 XI0_I964_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I964_MP20 (I0_pp8_21 I0_B_17_b3_3 XI0_I964_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I964_MP19 (XI0_I964_xp1 XI0_I964_xan I0_pp8_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I964_MP17 (VDD XI0_I964_xn XI0_I964_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I964_MP6 (XI0_I964_p1 I0_A_21_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I964_MP8 (XI0_I964_xn I0_A_20_b3_3 XI0_I964_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I964_MP7 (XI0_I964_p1 I0_two8_b3_3 XI0_I964_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I964_MP5 (VDD I0_one8_b3_3 XI0_I964_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I964_MP10 (XI0_I964_xan XI0_I964_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1018_MP12 (VDD I0_B_19_b3_3 XI0_I1018_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1018_MP18 (XI0_I1018_xp1 XI0_I1018_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1018_MP20 (I0_pp9_20 I0_B_19_b3_3 XI0_I1018_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1018_MP19 (XI0_I1018_xp1 XI0_I1018_xan I0_pp9_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1018_MP17 (VDD XI0_I1018_xn XI0_I1018_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1018_MP6 (XI0_I1018_p1 I0_A_20_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1018_MP8 (XI0_I1018_xn I0_A_19_b3_3 XI0_I1018_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1018_MP7 (XI0_I1018_p1 I0_two9_b3_3 XI0_I1018_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1018_MP5 (VDD I0_one9_b3_3 XI0_I1018_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1018_MP10 (XI0_I1018_xan XI0_I1018_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1016_MP12 (VDD I0_B_19_b3_3 XI0_I1016_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1016_MP18 (XI0_I1016_xp1 XI0_I1016_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1016_MP20 (I0_pp9_18 I0_B_19_b3_3 XI0_I1016_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1016_MP19 (XI0_I1016_xp1 XI0_I1016_xan I0_pp9_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1016_MP17 (VDD XI0_I1016_xn XI0_I1016_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1016_MP6 (XI0_I1016_p1 I0_A_18_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1016_MP8 (XI0_I1016_xn I0_A_17_b3_3 XI0_I1016_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1016_MP7 (XI0_I1016_p1 I0_two9_b3_3 XI0_I1016_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1016_MP5 (VDD I0_one9_b3_3 XI0_I1016_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1016_MP10 (XI0_I1016_xan XI0_I1016_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I946_MP12 (VDD I0_B_17_b3_0 XI0_I946_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I946_MP18 (XI0_I946_xp1 XI0_I946_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I946_MP20 (I0_pp8_3 I0_B_17_b3_0 XI0_I946_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I946_MP19 (XI0_I946_xp1 XI0_I946_xan I0_pp8_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I946_MP17 (VDD XI0_I946_xn XI0_I946_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I946_MP6 (XI0_I946_p1 I0_A_3_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I946_MP8 (XI0_I946_xn I0_A_2_b3_3 XI0_I946_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I946_MP7 (XI0_I946_p1 I0_two8_b3_0 XI0_I946_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I946_MP5 (VDD I0_one8_b3_0 XI0_I946_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I946_MP10 (XI0_I946_xan XI0_I946_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I947_MP12 (VDD I0_B_17_b3_0 XI0_I947_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I947_MP18 (XI0_I947_xp1 XI0_I947_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I947_MP20 (I0_pp8_4 I0_B_17_b3_0 XI0_I947_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I947_MP19 (XI0_I947_xp1 XI0_I947_xan I0_pp8_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I947_MP17 (VDD XI0_I947_xn XI0_I947_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I947_MP6 (XI0_I947_p1 I0_A_4_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I947_MP8 (XI0_I947_xn I0_A_3_b3_3 XI0_I947_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I947_MP7 (XI0_I947_p1 I0_two8_b3_0 XI0_I947_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I947_MP5 (VDD I0_one8_b3_0 XI0_I947_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I947_MP10 (XI0_I947_xan XI0_I947_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I948_MP12 (VDD I0_B_17_b3_1 XI0_I948_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I948_MP18 (XI0_I948_xp1 XI0_I948_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I948_MP20 (I0_pp8_5 I0_B_17_b3_1 XI0_I948_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I948_MP19 (XI0_I948_xp1 XI0_I948_xan I0_pp8_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I948_MP17 (VDD XI0_I948_xn XI0_I948_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I948_MP6 (XI0_I948_p1 I0_A_5_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I948_MP8 (XI0_I948_xn I0_A_4_b3_3 XI0_I948_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I948_MP7 (XI0_I948_p1 I0_two8_b3_0 XI0_I948_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I948_MP5 (VDD I0_one8_b3_0 XI0_I948_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I948_MP10 (XI0_I948_xan XI0_I948_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1007_MP12 (VDD I0_B_19_b3_1 XI0_I1007_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1007_MP18 (XI0_I1007_xp1 XI0_I1007_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1007_MP20 (I0_pp9_9 I0_B_19_b3_1 XI0_I1007_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1007_MP19 (XI0_I1007_xp1 XI0_I1007_xan I0_pp9_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1007_MP17 (VDD XI0_I1007_xn XI0_I1007_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1007_MP6 (XI0_I1007_p1 I0_A_9_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1007_MP8 (XI0_I1007_xn I0_A_8_b3_3 XI0_I1007_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1007_MP7 (XI0_I1007_p1 I0_two9_b3_1 XI0_I1007_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1007_MP5 (VDD I0_one9_b3_1 XI0_I1007_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1007_MP10 (XI0_I1007_xan XI0_I1007_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I951_MP12 (VDD I0_B_17_b3_1 XI0_I951_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I951_MP18 (XI0_I951_xp1 XI0_I951_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I951_MP20 (I0_pp8_8 I0_B_17_b3_1 XI0_I951_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I951_MP19 (XI0_I951_xp1 XI0_I951_xan I0_pp8_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I951_MP17 (VDD XI0_I951_xn XI0_I951_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I951_MP6 (XI0_I951_p1 I0_A_8_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I951_MP8 (XI0_I951_xn I0_A_7_b3_3 XI0_I951_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I951_MP7 (XI0_I951_p1 I0_two8_b3_1 XI0_I951_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I951_MP5 (VDD I0_one8_b3_1 XI0_I951_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I951_MP10 (XI0_I951_xan XI0_I951_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1058_MP12 (VDD I0_B_21_b3_1 XI0_I1058_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1058_MP18 (XI0_I1058_xp1 XI0_I1058_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1058_MP20 (I0_pp10_5 I0_B_21_b3_1 XI0_I1058_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1058_MP19 (XI0_I1058_xp1 XI0_I1058_xan I0_pp10_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1058_MP17 (VDD XI0_I1058_xn XI0_I1058_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1058_MP6 (XI0_I1058_p1 I0_A_5_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1058_MP8 (XI0_I1058_xn I0_A_4_b3_3 XI0_I1058_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1058_MP7 (XI0_I1058_p1 I0_two10_b3_0 XI0_I1058_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1058_MP5 (VDD I0_one10_b3_0 XI0_I1058_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1058_MP10 (XI0_I1058_xan XI0_I1058_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1059_MP12 (VDD I0_B_21_b3_1 XI0_I1059_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1059_MP18 (XI0_I1059_xp1 XI0_I1059_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1059_MP20 (I0_pp10_6 I0_B_21_b3_1 XI0_I1059_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1059_MP19 (XI0_I1059_xp1 XI0_I1059_xan I0_pp10_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1059_MP17 (VDD XI0_I1059_xn XI0_I1059_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1059_MP6 (XI0_I1059_p1 I0_A_6_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1059_MP8 (XI0_I1059_xn I0_A_5_b3_3 XI0_I1059_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1059_MP7 (XI0_I1059_p1 I0_two10_b3_1 XI0_I1059_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1059_MP5 (VDD I0_one10_b3_1 XI0_I1059_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1059_MP10 (XI0_I1059_xan XI0_I1059_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1060_MP12 (VDD I0_B_21_b3_1 XI0_I1060_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1060_MP18 (XI0_I1060_xp1 XI0_I1060_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1060_MP20 (I0_pp10_7 I0_B_21_b3_1 XI0_I1060_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1060_MP19 (XI0_I1060_xp1 XI0_I1060_xan I0_pp10_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1060_MP17 (VDD XI0_I1060_xn XI0_I1060_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1060_MP6 (XI0_I1060_p1 I0_A_7_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1060_MP8 (XI0_I1060_xn I0_A_6_b3_3 XI0_I1060_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1060_MP7 (XI0_I1060_p1 I0_two10_b3_1 XI0_I1060_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1060_MP5 (VDD I0_one10_b3_1 XI0_I1060_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1060_MP10 (XI0_I1060_xan XI0_I1060_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1117_MP12 (VDD I0_B_23_b3_1 XI0_I1117_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1117_MP18 (XI0_I1117_xp1 XI0_I1117_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1117_MP20 (I0_pp11_9 I0_B_23_b3_1 XI0_I1117_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1117_MP19 (XI0_I1117_xp1 XI0_I1117_xan I0_pp11_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1117_MP17 (VDD XI0_I1117_xn XI0_I1117_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1117_MP6 (XI0_I1117_p1 I0_A_9_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1117_MP8 (XI0_I1117_xn I0_A_8_b3_4 XI0_I1117_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1117_MP7 (XI0_I1117_p1 I0_two11_b3_1 XI0_I1117_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1117_MP5 (VDD I0_one11_b3_1 XI0_I1117_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1117_MP10 (XI0_I1117_xan XI0_I1117_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1118_MP12 (VDD I0_B_23_b3_1 XI0_I1118_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1118_MP18 (XI0_I1118_xp1 XI0_I1118_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1118_MP20 (I0_pp11_10 I0_B_23_b3_1 XI0_I1118_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1118_MP19 (XI0_I1118_xp1 XI0_I1118_xan I0_pp11_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1118_MP17 (VDD XI0_I1118_xn XI0_I1118_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1118_MP6 (XI0_I1118_p1 I0_A_10_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1118_MP8 (XI0_I1118_xn I0_A_9_b3_4 XI0_I1118_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1118_MP7 (XI0_I1118_p1 I0_two11_b3_1 XI0_I1118_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1118_MP5 (VDD I0_one11_b3_1 XI0_I1118_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1118_MP10 (XI0_I1118_xan XI0_I1118_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1116_MP12 (VDD I0_B_23_b3_1 XI0_I1116_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1116_MP18 (XI0_I1116_xp1 XI0_I1116_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1116_MP20 (I0_pp11_8 I0_B_23_b3_1 XI0_I1116_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1116_MP19 (XI0_I1116_xp1 XI0_I1116_xan I0_pp11_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1116_MP17 (VDD XI0_I1116_xn XI0_I1116_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1116_MP6 (XI0_I1116_p1 I0_A_8_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1116_MP8 (XI0_I1116_xn I0_A_7_b3_4 XI0_I1116_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1116_MP7 (XI0_I1116_p1 I0_two11_b3_1 XI0_I1116_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1116_MP5 (VDD I0_one11_b3_1 XI0_I1116_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1116_MP10 (XI0_I1116_xan XI0_I1116_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1119_MP12 (VDD I0_B_23_b3_2 XI0_I1119_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1119_MP18 (XI0_I1119_xp1 XI0_I1119_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1119_MP20 (I0_pp11_11 I0_B_23_b3_2 XI0_I1119_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1119_MP19 (XI0_I1119_xp1 XI0_I1119_xan I0_pp11_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1119_MP17 (VDD XI0_I1119_xn XI0_I1119_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1119_MP6 (XI0_I1119_p1 I0_A_11_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1119_MP8 (XI0_I1119_xn I0_A_10_b3_4 XI0_I1119_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1119_MP7 (XI0_I1119_p1 I0_two11_b3_2 XI0_I1119_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1119_MP5 (VDD I0_one11_b3_2 XI0_I1119_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1119_MP10 (XI0_I1119_xan XI0_I1119_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1120_MP12 (VDD I0_B_23_b3_2 XI0_I1120_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1120_MP18 (XI0_I1120_xp1 XI0_I1120_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1120_MP20 (I0_pp11_12 I0_B_23_b3_2 XI0_I1120_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1120_MP19 (XI0_I1120_xp1 XI0_I1120_xan I0_pp11_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1120_MP17 (VDD XI0_I1120_xn XI0_I1120_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1120_MP6 (XI0_I1120_p1 I0_A_12_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1120_MP8 (XI0_I1120_xn I0_A_11_b3_4 XI0_I1120_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1120_MP7 (XI0_I1120_p1 I0_two11_b3_2 XI0_I1120_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1120_MP5 (VDD I0_one11_b3_2 XI0_I1120_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1120_MP10 (XI0_I1120_xan XI0_I1120_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1121_MP12 (VDD I0_B_23_b3_2 XI0_I1121_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1121_MP18 (XI0_I1121_xp1 XI0_I1121_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1121_MP20 (I0_pp11_13 I0_B_23_b3_2 XI0_I1121_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1121_MP19 (XI0_I1121_xp1 XI0_I1121_xan I0_pp11_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1121_MP17 (VDD XI0_I1121_xn XI0_I1121_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1121_MP6 (XI0_I1121_p1 I0_A_13_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1121_MP8 (XI0_I1121_xn I0_A_12_b3_4 XI0_I1121_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1121_MP7 (XI0_I1121_p1 I0_two11_b3_2 XI0_I1121_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1121_MP5 (VDD I0_one11_b3_2 XI0_I1121_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1121_MP10 (XI0_I1121_xan XI0_I1121_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1122_MP12 (VDD I0_B_23_b3_2 XI0_I1122_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1122_MP18 (XI0_I1122_xp1 XI0_I1122_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1122_MP20 (I0_pp11_14 I0_B_23_b3_2 XI0_I1122_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1122_MP19 (XI0_I1122_xp1 XI0_I1122_xan I0_pp11_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1122_MP17 (VDD XI0_I1122_xn XI0_I1122_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1122_MP6 (XI0_I1122_p1 I0_A_14_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1122_MP8 (XI0_I1122_xn I0_A_13_b3_4 XI0_I1122_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1122_MP7 (XI0_I1122_p1 I0_two11_b3_2 XI0_I1122_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1122_MP5 (VDD I0_one11_b3_2 XI0_I1122_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1122_MP10 (XI0_I1122_xan XI0_I1122_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1070_MP12 (VDD I0_B_21_b3_3 XI0_I1070_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1070_MP18 (XI0_I1070_xp1 XI0_I1070_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1070_MP20 (I0_pp10_17 I0_B_21_b3_3 XI0_I1070_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1070_MP19 (XI0_I1070_xp1 XI0_I1070_xan I0_pp10_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1070_MP17 (VDD XI0_I1070_xn XI0_I1070_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1070_MP6 (XI0_I1070_p1 I0_A_17_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1070_MP8 (XI0_I1070_xn I0_A_16_b3_3 XI0_I1070_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1070_MP7 (XI0_I1070_p1 I0_two10_b3_3 XI0_I1070_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1070_MP5 (VDD I0_one10_b3_3 XI0_I1070_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1070_MP10 (XI0_I1070_xan XI0_I1070_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1071_MP12 (VDD I0_B_21_b3_3 XI0_I1071_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1071_MP18 (XI0_I1071_xp1 XI0_I1071_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1071_MP20 (I0_pp10_18 I0_B_21_b3_3 XI0_I1071_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1071_MP19 (XI0_I1071_xp1 XI0_I1071_xan I0_pp10_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1071_MP17 (VDD XI0_I1071_xn XI0_I1071_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1071_MP6 (XI0_I1071_p1 I0_A_18_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1071_MP8 (XI0_I1071_xn I0_A_17_b3_3 XI0_I1071_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1071_MP7 (XI0_I1071_p1 I0_two10_b3_3 XI0_I1071_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1071_MP5 (VDD I0_one10_b3_3 XI0_I1071_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1071_MP10 (XI0_I1071_xan XI0_I1071_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1019_MP12 (VDD I0_B_19_b3_3 XI0_I1019_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1019_MP18 (XI0_I1019_xp1 XI0_I1019_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1019_MP20 (I0_pp9_21 I0_B_19_b3_3 XI0_I1019_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1019_MP19 (XI0_I1019_xp1 XI0_I1019_xan I0_pp9_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1019_MP17 (VDD XI0_I1019_xn XI0_I1019_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1019_MP6 (XI0_I1019_p1 I0_A_21_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1019_MP8 (XI0_I1019_xn I0_A_20_b3_3 XI0_I1019_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1019_MP7 (XI0_I1019_p1 I0_two9_b3_3 XI0_I1019_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1019_MP5 (VDD I0_one9_b3_3 XI0_I1019_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1019_MP10 (XI0_I1019_xan XI0_I1019_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I945_MP12 (VDD I0_B_17_b3_0 XI0_I945_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I945_MP18 (XI0_I945_xp1 XI0_I945_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I945_MP20 (I0_pp8_2 I0_B_17_b3_0 XI0_I945_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I945_MP19 (XI0_I945_xp1 XI0_I945_xan I0_pp8_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I945_MP17 (VDD XI0_I945_xn XI0_I945_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I945_MP6 (XI0_I945_p1 I0_A_2_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I945_MP8 (XI0_I945_xn I0_A_1_b3_3 XI0_I945_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I945_MP7 (XI0_I945_p1 I0_two8_b3_0 XI0_I945_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I945_MP5 (VDD I0_one8_b3_0 XI0_I945_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I945_MP10 (XI0_I945_xan XI0_I945_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I943_MP12 (VDD I0_B_17_b3_0 XI0_I943_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I943_MP18 (XI0_I943_xp1 XI0_I943_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I943_MP20 (I0_pp8_0 I0_B_17_b3_0 XI0_I943_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I943_MP19 (XI0_I943_xp1 XI0_I943_xan I0_pp8_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I943_MP17 (VDD XI0_I943_xn XI0_I943_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I943_MP6 (XI0_I943_p1 I0_A_0_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I943_MP8 (XI0_I943_xn VSS XI0_I943_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I943_MP7 (XI0_I943_p1 I0_two8_b3_0 XI0_I943_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I943_MP5 (VDD I0_one8_b3_0 XI0_I943_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I943_MP10 (XI0_I943_xan XI0_I943_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I944_MP12 (VDD I0_B_17_b3_0 XI0_I944_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I944_MP18 (XI0_I944_xp1 XI0_I944_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I944_MP20 (I0_pp8_1 I0_B_17_b3_0 XI0_I944_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I944_MP19 (XI0_I944_xp1 XI0_I944_xan I0_pp8_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I944_MP17 (VDD XI0_I944_xn XI0_I944_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I944_MP6 (XI0_I944_p1 I0_A_1_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I944_MP8 (XI0_I944_xn I0_A_0_b3_3 XI0_I944_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I944_MP7 (XI0_I944_p1 I0_two8_b3_0 XI0_I944_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I944_MP5 (VDD I0_one8_b3_0 XI0_I944_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I944_MP10 (XI0_I944_xan XI0_I944_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1053_MP12 (VDD I0_B_21_b3_0 XI0_I1053_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1053_MP18 (XI0_I1053_xp1 XI0_I1053_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1053_MP20 (I0_pp10_0 I0_B_21_b3_0 XI0_I1053_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1053_MP19 (XI0_I1053_xp1 XI0_I1053_xan I0_pp10_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1053_MP17 (VDD XI0_I1053_xn XI0_I1053_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1053_MP6 (XI0_I1053_p1 I0_A_0_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1053_MP8 (XI0_I1053_xn VSS XI0_I1053_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1053_MP7 (XI0_I1053_p1 I0_two10_b3_0 XI0_I1053_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1053_MP5 (VDD I0_one10_b3_0 XI0_I1053_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1053_MP10 (XI0_I1053_xan XI0_I1053_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1054_MP12 (VDD I0_B_21_b3_0 XI0_I1054_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1054_MP18 (XI0_I1054_xp1 XI0_I1054_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1054_MP20 (I0_pp10_1 I0_B_21_b3_0 XI0_I1054_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1054_MP19 (XI0_I1054_xp1 XI0_I1054_xan I0_pp10_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1054_MP17 (VDD XI0_I1054_xn XI0_I1054_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1054_MP6 (XI0_I1054_p1 I0_A_1_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1054_MP8 (XI0_I1054_xn I0_A_0_b3_3 XI0_I1054_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1054_MP7 (XI0_I1054_p1 I0_two10_b3_0 XI0_I1054_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1054_MP5 (VDD I0_one10_b3_0 XI0_I1054_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1054_MP10 (XI0_I1054_xan XI0_I1054_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1055_MP12 (VDD I0_B_21_b3_0 XI0_I1055_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1055_MP18 (XI0_I1055_xp1 XI0_I1055_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1055_MP20 (I0_pp10_2 I0_B_21_b3_0 XI0_I1055_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1055_MP19 (XI0_I1055_xp1 XI0_I1055_xan I0_pp10_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1055_MP17 (VDD XI0_I1055_xn XI0_I1055_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1055_MP6 (XI0_I1055_p1 I0_A_2_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1055_MP8 (XI0_I1055_xn I0_A_1_b3_3 XI0_I1055_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1055_MP7 (XI0_I1055_p1 I0_two10_b3_0 XI0_I1055_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1055_MP5 (VDD I0_one10_b3_0 XI0_I1055_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1055_MP10 (XI0_I1055_xan XI0_I1055_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I950_MP12 (VDD I0_B_17_b3_1 XI0_I950_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I950_MP18 (XI0_I950_xp1 XI0_I950_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I950_MP20 (I0_pp8_7 I0_B_17_b3_1 XI0_I950_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I950_MP19 (XI0_I950_xp1 XI0_I950_xan I0_pp8_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I950_MP17 (VDD XI0_I950_xn XI0_I950_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I950_MP6 (XI0_I950_p1 I0_A_7_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I950_MP8 (XI0_I950_xn I0_A_6_b3_3 XI0_I950_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I950_MP7 (XI0_I950_p1 I0_two8_b3_1 XI0_I950_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I950_MP5 (VDD I0_one8_b3_1 XI0_I950_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I950_MP10 (XI0_I950_xan XI0_I950_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1057_MP12 (VDD I0_B_21_b3_0 XI0_I1057_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1057_MP18 (XI0_I1057_xp1 XI0_I1057_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1057_MP20 (I0_pp10_4 I0_B_21_b3_0 XI0_I1057_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1057_MP19 (XI0_I1057_xp1 XI0_I1057_xan I0_pp10_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1057_MP17 (VDD XI0_I1057_xn XI0_I1057_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1057_MP6 (XI0_I1057_p1 I0_A_4_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1057_MP8 (XI0_I1057_xn I0_A_3_b3_3 XI0_I1057_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1057_MP7 (XI0_I1057_p1 I0_two10_b3_0 XI0_I1057_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1057_MP5 (VDD I0_one10_b3_0 XI0_I1057_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1057_MP10 (XI0_I1057_xan XI0_I1057_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1002_MP12 (VDD I0_B_19_b3_0 XI0_I1002_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1002_MP18 (XI0_I1002_xp1 XI0_I1002_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1002_MP20 (I0_pp9_4 I0_B_19_b3_0 XI0_I1002_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1002_MP19 (XI0_I1002_xp1 XI0_I1002_xan I0_pp9_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1002_MP17 (VDD XI0_I1002_xn XI0_I1002_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1002_MP6 (XI0_I1002_p1 I0_A_4_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1002_MP8 (XI0_I1002_xn I0_A_3_b3_3 XI0_I1002_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1002_MP7 (XI0_I1002_p1 I0_two9_b3_0 XI0_I1002_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1002_MP5 (VDD I0_one9_b3_0 XI0_I1002_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1002_MP10 (XI0_I1002_xan XI0_I1002_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1003_MP12 (VDD I0_B_19_b3_1 XI0_I1003_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1003_MP18 (XI0_I1003_xp1 XI0_I1003_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1003_MP20 (I0_pp9_5 I0_B_19_b3_1 XI0_I1003_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1003_MP19 (XI0_I1003_xp1 XI0_I1003_xan I0_pp9_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1003_MP17 (VDD XI0_I1003_xn XI0_I1003_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1003_MP6 (XI0_I1003_p1 I0_A_5_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1003_MP8 (XI0_I1003_xn I0_A_4_b3_3 XI0_I1003_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1003_MP7 (XI0_I1003_p1 I0_two9_b3_0 XI0_I1003_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1003_MP5 (VDD I0_one9_b3_0 XI0_I1003_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1003_MP10 (XI0_I1003_xan XI0_I1003_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1004_MP12 (VDD I0_B_19_b3_1 XI0_I1004_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1004_MP18 (XI0_I1004_xp1 XI0_I1004_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1004_MP20 (I0_pp9_6 I0_B_19_b3_1 XI0_I1004_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1004_MP19 (XI0_I1004_xp1 XI0_I1004_xan I0_pp9_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1004_MP17 (VDD XI0_I1004_xn XI0_I1004_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1004_MP6 (XI0_I1004_p1 I0_A_6_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1004_MP8 (XI0_I1004_xn I0_A_5_b3_3 XI0_I1004_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1004_MP7 (XI0_I1004_p1 I0_two9_b3_1 XI0_I1004_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1004_MP5 (VDD I0_one9_b3_1 XI0_I1004_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1004_MP10 (XI0_I1004_xan XI0_I1004_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1005_MP12 (VDD I0_B_19_b3_1 XI0_I1005_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1005_MP18 (XI0_I1005_xp1 XI0_I1005_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1005_MP20 (I0_pp9_7 I0_B_19_b3_1 XI0_I1005_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1005_MP19 (XI0_I1005_xp1 XI0_I1005_xan I0_pp9_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1005_MP17 (VDD XI0_I1005_xn XI0_I1005_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1005_MP6 (XI0_I1005_p1 I0_A_7_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1005_MP8 (XI0_I1005_xn I0_A_6_b3_3 XI0_I1005_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1005_MP7 (XI0_I1005_p1 I0_two9_b3_1 XI0_I1005_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1005_MP5 (VDD I0_one9_b3_1 XI0_I1005_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1005_MP10 (XI0_I1005_xan XI0_I1005_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1115_MP12 (VDD I0_B_23_b3_1 XI0_I1115_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1115_MP18 (XI0_I1115_xp1 XI0_I1115_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1115_MP20 (I0_pp11_7 I0_B_23_b3_1 XI0_I1115_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1115_MP19 (XI0_I1115_xp1 XI0_I1115_xan I0_pp11_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1115_MP17 (VDD XI0_I1115_xn XI0_I1115_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1115_MP6 (XI0_I1115_p1 I0_A_7_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1115_MP8 (XI0_I1115_xn I0_A_6_b3_4 XI0_I1115_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1115_MP7 (XI0_I1115_p1 I0_two11_b3_1 XI0_I1115_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1115_MP5 (VDD I0_one11_b3_1 XI0_I1115_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1115_MP10 (XI0_I1115_xan XI0_I1115_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1172_MP12 (VDD I0_B_25_b3_1 XI0_I1172_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1172_MP18 (XI0_I1172_xp1 XI0_I1172_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1172_MP20 (I0_pp12_9 I0_B_25_b3_1 XI0_I1172_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1172_MP19 (XI0_I1172_xp1 XI0_I1172_xan I0_pp12_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1172_MP17 (VDD XI0_I1172_xn XI0_I1172_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1172_MP6 (XI0_I1172_p1 I0_A_9_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1172_MP8 (XI0_I1172_xn I0_A_8_b3_4 XI0_I1172_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1172_MP7 (XI0_I1172_p1 I0_two12_b3_1 XI0_I1172_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1172_MP5 (VDD I0_one12_b3_1 XI0_I1172_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1172_MP10 (XI0_I1172_xan XI0_I1172_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1173_MP12 (VDD I0_B_25_b3_1 XI0_I1173_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1173_MP18 (XI0_I1173_xp1 XI0_I1173_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1173_MP20 (I0_pp12_10 I0_B_25_b3_1 XI0_I1173_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1173_MP19 (XI0_I1173_xp1 XI0_I1173_xan I0_pp12_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1173_MP17 (VDD XI0_I1173_xn XI0_I1173_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1173_MP6 (XI0_I1173_p1 I0_A_10_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1173_MP8 (XI0_I1173_xn I0_A_9_b3_4 XI0_I1173_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1173_MP7 (XI0_I1173_p1 I0_two12_b3_1 XI0_I1173_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1173_MP5 (VDD I0_one12_b3_1 XI0_I1173_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1173_MP10 (XI0_I1173_xan XI0_I1173_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1227_MP12 (VDD I0_B_27_b3_1 XI0_I1227_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1227_MP18 (XI0_I1227_xp1 XI0_I1227_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1227_MP20 (I0_pp13_9 I0_B_27_b3_1 XI0_I1227_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1227_MP19 (XI0_I1227_xp1 XI0_I1227_xan I0_pp13_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1227_MP17 (VDD XI0_I1227_xn XI0_I1227_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1227_MP6 (XI0_I1227_p1 I0_A_9_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1227_MP8 (XI0_I1227_xn I0_A_8_b3_5 XI0_I1227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1227_MP7 (XI0_I1227_p1 I0_two13_b3_1 XI0_I1227_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1227_MP5 (VDD I0_one13_b3_1 XI0_I1227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1227_MP10 (XI0_I1227_xan XI0_I1227_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1280_MP12 (VDD I0_B_29_b3_1 XI0_I1280_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1280_MP18 (XI0_I1280_xp1 XI0_I1280_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1280_MP20 (I0_pp14_7 I0_B_29_b3_1 XI0_I1280_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1280_MP19 (XI0_I1280_xp1 XI0_I1280_xan I0_pp14_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1280_MP17 (VDD XI0_I1280_xn XI0_I1280_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1280_MP6 (XI0_I1280_p1 I0_A_7_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1280_MP8 (XI0_I1280_xn I0_A_6_b3_5 XI0_I1280_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1280_MP7 (XI0_I1280_p1 I0_two14_b3_1 XI0_I1280_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1280_MP5 (VDD I0_one14_b3_1 XI0_I1280_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1280_MP10 (XI0_I1280_xan XI0_I1280_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1174_MP12 (VDD I0_B_25_b3_2 XI0_I1174_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1174_MP18 (XI0_I1174_xp1 XI0_I1174_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1174_MP20 (I0_pp12_11 I0_B_25_b3_2 XI0_I1174_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1174_MP19 (XI0_I1174_xp1 XI0_I1174_xan I0_pp12_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1174_MP17 (VDD XI0_I1174_xn XI0_I1174_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1174_MP6 (XI0_I1174_p1 I0_A_11_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1174_MP8 (XI0_I1174_xn I0_A_10_b3_4 XI0_I1174_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1174_MP7 (XI0_I1174_p1 I0_two12_b3_2 XI0_I1174_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1174_MP5 (VDD I0_one12_b3_2 XI0_I1174_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1174_MP10 (XI0_I1174_xan XI0_I1174_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1283_MP12 (VDD I0_B_29_b3_1 XI0_I1283_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1283_MP18 (XI0_I1283_xp1 XI0_I1283_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1283_MP20 (I0_pp14_10 I0_B_29_b3_1 XI0_I1283_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1283_MP19 (XI0_I1283_xp1 XI0_I1283_xan I0_pp14_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1283_MP17 (VDD XI0_I1283_xn XI0_I1283_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1283_MP6 (XI0_I1283_p1 I0_A_10_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1283_MP8 (XI0_I1283_xn I0_A_9_b3_5 XI0_I1283_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1283_MP7 (XI0_I1283_p1 I0_two14_b3_1 XI0_I1283_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1283_MP5 (VDD I0_one14_b3_1 XI0_I1283_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1283_MP10 (XI0_I1283_xan XI0_I1283_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1175_MP12 (VDD I0_B_25_b3_2 XI0_I1175_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1175_MP18 (XI0_I1175_xp1 XI0_I1175_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1175_MP20 (I0_pp12_12 I0_B_25_b3_2 XI0_I1175_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1175_MP19 (XI0_I1175_xp1 XI0_I1175_xan I0_pp12_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1175_MP17 (VDD XI0_I1175_xn XI0_I1175_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1175_MP6 (XI0_I1175_p1 I0_A_12_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1175_MP8 (XI0_I1175_xn I0_A_11_b3_4 XI0_I1175_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1175_MP7 (XI0_I1175_p1 I0_two12_b3_2 XI0_I1175_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1175_MP5 (VDD I0_one12_b3_2 XI0_I1175_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1175_MP10 (XI0_I1175_xan XI0_I1175_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1229_MP12 (VDD I0_B_27_b3_2 XI0_I1229_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1229_MP18 (XI0_I1229_xp1 XI0_I1229_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1229_MP20 (I0_pp13_11 I0_B_27_b3_2 XI0_I1229_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1229_MP19 (XI0_I1229_xp1 XI0_I1229_xan I0_pp13_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1229_MP17 (VDD XI0_I1229_xn XI0_I1229_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1229_MP6 (XI0_I1229_p1 I0_A_11_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1229_MP8 (XI0_I1229_xn I0_A_10_b3_5 XI0_I1229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1229_MP7 (XI0_I1229_p1 I0_two13_b3_2 XI0_I1229_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1229_MP5 (VDD I0_one13_b3_2 XI0_I1229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1229_MP10 (XI0_I1229_xan XI0_I1229_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1123_MP12 (VDD I0_B_23_b3_2 XI0_I1123_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1123_MP18 (XI0_I1123_xp1 XI0_I1123_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1123_MP20 (I0_pp11_15 I0_B_23_b3_2 XI0_I1123_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1123_MP19 (XI0_I1123_xp1 XI0_I1123_xan I0_pp11_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1123_MP17 (VDD XI0_I1123_xn XI0_I1123_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1123_MP6 (XI0_I1123_p1 I0_A_15_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1123_MP8 (XI0_I1123_xn I0_A_14_b3_4 XI0_I1123_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1123_MP7 (XI0_I1123_p1 I0_two11_b3_2 XI0_I1123_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1123_MP5 (VDD I0_one11_b3_2 XI0_I1123_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1123_MP10 (XI0_I1123_xan XI0_I1123_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1176_MP12 (VDD I0_B_25_b3_2 XI0_I1176_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1176_MP18 (XI0_I1176_xp1 XI0_I1176_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1176_MP20 (I0_pp12_13 I0_B_25_b3_2 XI0_I1176_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1176_MP19 (XI0_I1176_xp1 XI0_I1176_xan I0_pp12_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1176_MP17 (VDD XI0_I1176_xn XI0_I1176_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1176_MP6 (XI0_I1176_p1 I0_A_13_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1176_MP8 (XI0_I1176_xn I0_A_12_b3_4 XI0_I1176_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1176_MP7 (XI0_I1176_p1 I0_two12_b3_2 XI0_I1176_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1176_MP5 (VDD I0_one12_b3_2 XI0_I1176_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1176_MP10 (XI0_I1176_xan XI0_I1176_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1124_MP12 (VDD I0_B_23_b3_2 XI0_I1124_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1124_MP18 (XI0_I1124_xp1 XI0_I1124_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1124_MP20 (I0_pp11_16 I0_B_23_b3_2 XI0_I1124_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1124_MP19 (XI0_I1124_xp1 XI0_I1124_xan I0_pp11_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1124_MP17 (VDD XI0_I1124_xn XI0_I1124_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1124_MP6 (XI0_I1124_p1 I0_A_16_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1124_MP8 (XI0_I1124_xn I0_A_15_b3_4 XI0_I1124_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1124_MP7 (XI0_I1124_p1 I0_two11_b3_2 XI0_I1124_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1124_MP5 (VDD I0_one11_b3_2 XI0_I1124_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1124_MP10 (XI0_I1124_xan XI0_I1124_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1072_MP12 (VDD I0_B_21_b3_3 XI0_I1072_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1072_MP18 (XI0_I1072_xp1 XI0_I1072_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1072_MP20 (I0_pp10_19 I0_B_21_b3_3 XI0_I1072_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1072_MP19 (XI0_I1072_xp1 XI0_I1072_xan I0_pp10_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1072_MP17 (VDD XI0_I1072_xn XI0_I1072_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1072_MP6 (XI0_I1072_p1 I0_A_19_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1072_MP8 (XI0_I1072_xn I0_A_18_b3_3 XI0_I1072_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1072_MP7 (XI0_I1072_p1 I0_two10_b3_3 XI0_I1072_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1072_MP5 (VDD I0_one10_b3_3 XI0_I1072_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1072_MP10 (XI0_I1072_xan XI0_I1072_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1073_MP12 (VDD I0_B_21_b3_3 XI0_I1073_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1073_MP18 (XI0_I1073_xp1 XI0_I1073_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1073_MP20 (I0_pp10_20 I0_B_21_b3_3 XI0_I1073_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1073_MP19 (XI0_I1073_xp1 XI0_I1073_xan I0_pp10_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1073_MP17 (VDD XI0_I1073_xn XI0_I1073_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1073_MP6 (XI0_I1073_p1 I0_A_20_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1073_MP8 (XI0_I1073_xn I0_A_19_b3_3 XI0_I1073_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1073_MP7 (XI0_I1073_p1 I0_two10_b3_3 XI0_I1073_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1073_MP5 (VDD I0_one10_b3_3 XI0_I1073_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1073_MP10 (XI0_I1073_xan XI0_I1073_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1074_MP12 (VDD I0_B_21_b3_3 XI0_I1074_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1074_MP18 (XI0_I1074_xp1 XI0_I1074_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1074_MP20 (I0_pp10_21 I0_B_21_b3_3 XI0_I1074_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1074_MP19 (XI0_I1074_xp1 XI0_I1074_xan I0_pp10_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1074_MP17 (VDD XI0_I1074_xn XI0_I1074_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1074_MP6 (XI0_I1074_p1 I0_A_21_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1074_MP8 (XI0_I1074_xn I0_A_20_b3_3 XI0_I1074_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1074_MP7 (XI0_I1074_p1 I0_two10_b3_3 XI0_I1074_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1074_MP5 (VDD I0_one10_b3_3 XI0_I1074_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1074_MP10 (XI0_I1074_xan XI0_I1074_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I998_MP12 (VDD I0_B_19_b3_0 XI0_I998_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I998_MP18 (XI0_I998_xp1 XI0_I998_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I998_MP20 (I0_pp9_0 I0_B_19_b3_0 XI0_I998_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I998_MP19 (XI0_I998_xp1 XI0_I998_xan I0_pp9_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I998_MP17 (VDD XI0_I998_xn XI0_I998_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I998_MP6 (XI0_I998_p1 I0_A_0_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I998_MP8 (XI0_I998_xn VSS XI0_I998_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I998_MP7 (XI0_I998_p1 I0_two9_b3_0 XI0_I998_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I998_MP5 (VDD I0_one9_b3_0 XI0_I998_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I998_MP10 (XI0_I998_xan XI0_I998_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1000_MP12 (VDD I0_B_19_b3_0 XI0_I1000_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1000_MP18 (XI0_I1000_xp1 XI0_I1000_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1000_MP20 (I0_pp9_2 I0_B_19_b3_0 XI0_I1000_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1000_MP19 (XI0_I1000_xp1 XI0_I1000_xan I0_pp9_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1000_MP17 (VDD XI0_I1000_xn XI0_I1000_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1000_MP6 (XI0_I1000_p1 I0_A_2_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1000_MP8 (XI0_I1000_xn I0_A_1_b3_3 XI0_I1000_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1000_MP7 (XI0_I1000_p1 I0_two9_b3_0 XI0_I1000_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1000_MP5 (VDD I0_one9_b3_0 XI0_I1000_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1000_MP10 (XI0_I1000_xan XI0_I1000_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I999_MP12 (VDD I0_B_19_b3_0 XI0_I999_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I999_MP18 (XI0_I999_xp1 XI0_I999_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I999_MP20 (I0_pp9_1 I0_B_19_b3_0 XI0_I999_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I999_MP19 (XI0_I999_xp1 XI0_I999_xan I0_pp9_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I999_MP17 (VDD XI0_I999_xn XI0_I999_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I999_MP6 (XI0_I999_p1 I0_A_1_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I999_MP8 (XI0_I999_xn I0_A_0_b3_3 XI0_I999_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I999_MP7 (XI0_I999_p1 I0_two9_b3_0 XI0_I999_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I999_MP5 (VDD I0_one9_b3_0 XI0_I999_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I999_MP10 (XI0_I999_xan XI0_I999_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1001_MP12 (VDD I0_B_19_b3_0 XI0_I1001_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1001_MP18 (XI0_I1001_xp1 XI0_I1001_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1001_MP20 (I0_pp9_3 I0_B_19_b3_0 XI0_I1001_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1001_MP19 (XI0_I1001_xp1 XI0_I1001_xan I0_pp9_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1001_MP17 (VDD XI0_I1001_xn XI0_I1001_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1001_MP6 (XI0_I1001_p1 I0_A_3_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1001_MP8 (XI0_I1001_xn I0_A_2_b3_3 XI0_I1001_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1001_MP7 (XI0_I1001_p1 I0_two9_b3_0 XI0_I1001_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1001_MP5 (VDD I0_one9_b3_0 XI0_I1001_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1001_MP10 (XI0_I1001_xan XI0_I1001_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1056_MP12 (VDD I0_B_21_b3_0 XI0_I1056_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1056_MP18 (XI0_I1056_xp1 XI0_I1056_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1056_MP20 (I0_pp10_3 I0_B_21_b3_0 XI0_I1056_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1056_MP19 (XI0_I1056_xp1 XI0_I1056_xan I0_pp10_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1056_MP17 (VDD XI0_I1056_xn XI0_I1056_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1056_MP6 (XI0_I1056_p1 I0_A_3_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1056_MP8 (XI0_I1056_xn I0_A_2_b3_3 XI0_I1056_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1056_MP7 (XI0_I1056_p1 I0_two10_b3_0 XI0_I1056_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1056_MP5 (VDD I0_one10_b3_0 XI0_I1056_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1056_MP10 (XI0_I1056_xan XI0_I1056_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I949_MP12 (VDD I0_B_17_b3_1 XI0_I949_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I949_MP18 (XI0_I949_xp1 XI0_I949_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I949_MP20 (I0_pp8_6 I0_B_17_b3_1 XI0_I949_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I949_MP19 (XI0_I949_xp1 XI0_I949_xan I0_pp8_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I949_MP17 (VDD XI0_I949_xn XI0_I949_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I949_MP6 (XI0_I949_p1 I0_A_6_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I949_MP8 (XI0_I949_xn I0_A_5_b3_3 XI0_I949_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I949_MP7 (XI0_I949_p1 I0_two8_b3_1 XI0_I949_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I949_MP5 (VDD I0_one8_b3_1 XI0_I949_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I949_MP10 (XI0_I949_xan XI0_I949_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1110_MP12 (VDD I0_B_23_b3_0 XI0_I1110_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1110_MP18 (XI0_I1110_xp1 XI0_I1110_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1110_MP20 (I0_pp11_2 I0_B_23_b3_0 XI0_I1110_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1110_MP19 (XI0_I1110_xp1 XI0_I1110_xan I0_pp11_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1110_MP17 (VDD XI0_I1110_xn XI0_I1110_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1110_MP6 (XI0_I1110_p1 I0_A_2_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1110_MP8 (XI0_I1110_xn I0_A_1_b3_4 XI0_I1110_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1110_MP7 (XI0_I1110_p1 I0_two11_b3_0 XI0_I1110_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1110_MP5 (VDD I0_one11_b3_0 XI0_I1110_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1110_MP10 (XI0_I1110_xan XI0_I1110_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1112_MP12 (VDD I0_B_23_b3_0 XI0_I1112_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1112_MP18 (XI0_I1112_xp1 XI0_I1112_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1112_MP20 (I0_pp11_4 I0_B_23_b3_0 XI0_I1112_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1112_MP19 (XI0_I1112_xp1 XI0_I1112_xan I0_pp11_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1112_MP17 (VDD XI0_I1112_xn XI0_I1112_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1112_MP6 (XI0_I1112_p1 I0_A_4_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1112_MP8 (XI0_I1112_xn I0_A_3_b3_4 XI0_I1112_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1112_MP7 (XI0_I1112_p1 I0_two11_b3_0 XI0_I1112_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1112_MP5 (VDD I0_one11_b3_0 XI0_I1112_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1112_MP10 (XI0_I1112_xan XI0_I1112_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1114_MP12 (VDD I0_B_23_b3_1 XI0_I1114_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1114_MP18 (XI0_I1114_xp1 XI0_I1114_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1114_MP20 (I0_pp11_6 I0_B_23_b3_1 XI0_I1114_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1114_MP19 (XI0_I1114_xp1 XI0_I1114_xan I0_pp11_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1114_MP17 (VDD XI0_I1114_xn XI0_I1114_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1114_MP6 (XI0_I1114_p1 I0_A_6_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1114_MP8 (XI0_I1114_xn I0_A_5_b3_4 XI0_I1114_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1114_MP7 (XI0_I1114_p1 I0_two11_b3_1 XI0_I1114_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1114_MP5 (VDD I0_one11_b3_1 XI0_I1114_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1114_MP10 (XI0_I1114_xan XI0_I1114_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1113_MP12 (VDD I0_B_23_b3_1 XI0_I1113_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1113_MP18 (XI0_I1113_xp1 XI0_I1113_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1113_MP20 (I0_pp11_5 I0_B_23_b3_1 XI0_I1113_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1113_MP19 (XI0_I1113_xp1 XI0_I1113_xan I0_pp11_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1113_MP17 (VDD XI0_I1113_xn XI0_I1113_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1113_MP6 (XI0_I1113_p1 I0_A_5_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1113_MP8 (XI0_I1113_xn I0_A_4_b3_4 XI0_I1113_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1113_MP7 (XI0_I1113_p1 I0_two11_b3_0 XI0_I1113_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1113_MP5 (VDD I0_one11_b3_0 XI0_I1113_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1113_MP10 (XI0_I1113_xan XI0_I1113_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1170_MP12 (VDD I0_B_25_b3_1 XI0_I1170_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1170_MP18 (XI0_I1170_xp1 XI0_I1170_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1170_MP20 (I0_pp12_7 I0_B_25_b3_1 XI0_I1170_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1170_MP19 (XI0_I1170_xp1 XI0_I1170_xan I0_pp12_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1170_MP17 (VDD XI0_I1170_xn XI0_I1170_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1170_MP6 (XI0_I1170_p1 I0_A_7_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1170_MP8 (XI0_I1170_xn I0_A_6_b3_4 XI0_I1170_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1170_MP7 (XI0_I1170_p1 I0_two12_b3_1 XI0_I1170_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1170_MP5 (VDD I0_one12_b3_1 XI0_I1170_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1170_MP10 (XI0_I1170_xan XI0_I1170_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1225_MP12 (VDD I0_B_27_b3_1 XI0_I1225_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1225_MP18 (XI0_I1225_xp1 XI0_I1225_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1225_MP20 (I0_pp13_7 I0_B_27_b3_1 XI0_I1225_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1225_MP19 (XI0_I1225_xp1 XI0_I1225_xan I0_pp13_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1225_MP17 (VDD XI0_I1225_xn XI0_I1225_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1225_MP6 (XI0_I1225_p1 I0_A_7_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1225_MP8 (XI0_I1225_xn I0_A_6_b3_5 XI0_I1225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1225_MP7 (XI0_I1225_p1 I0_two13_b3_1 XI0_I1225_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1225_MP5 (VDD I0_one13_b3_1 XI0_I1225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1225_MP10 (XI0_I1225_xan XI0_I1225_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1171_MP12 (VDD I0_B_25_b3_1 XI0_I1171_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1171_MP18 (XI0_I1171_xp1 XI0_I1171_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1171_MP20 (I0_pp12_8 I0_B_25_b3_1 XI0_I1171_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1171_MP19 (XI0_I1171_xp1 XI0_I1171_xan I0_pp12_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1171_MP17 (VDD XI0_I1171_xn XI0_I1171_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1171_MP6 (XI0_I1171_p1 I0_A_8_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1171_MP8 (XI0_I1171_xn I0_A_7_b3_4 XI0_I1171_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1171_MP7 (XI0_I1171_p1 I0_two12_b3_1 XI0_I1171_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1171_MP5 (VDD I0_one12_b3_1 XI0_I1171_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1171_MP10 (XI0_I1171_xan XI0_I1171_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1226_MP12 (VDD I0_B_27_b3_1 XI0_I1226_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1226_MP18 (XI0_I1226_xp1 XI0_I1226_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1226_MP20 (I0_pp13_8 I0_B_27_b3_1 XI0_I1226_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1226_MP19 (XI0_I1226_xp1 XI0_I1226_xan I0_pp13_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1226_MP17 (VDD XI0_I1226_xn XI0_I1226_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1226_MP6 (XI0_I1226_p1 I0_A_8_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1226_MP8 (XI0_I1226_xn I0_A_7_b3_5 XI0_I1226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1226_MP7 (XI0_I1226_p1 I0_two13_b3_1 XI0_I1226_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1226_MP5 (VDD I0_one13_b3_1 XI0_I1226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1226_MP10 (XI0_I1226_xan XI0_I1226_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1228_MP12 (VDD I0_B_27_b3_1 XI0_I1228_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1228_MP18 (XI0_I1228_xp1 XI0_I1228_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1228_MP20 (I0_pp13_10 I0_B_27_b3_1 XI0_I1228_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1228_MP19 (XI0_I1228_xp1 XI0_I1228_xan I0_pp13_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1228_MP17 (VDD XI0_I1228_xn XI0_I1228_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1228_MP6 (XI0_I1228_p1 I0_A_10_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1228_MP8 (XI0_I1228_xn I0_A_9_b3_5 XI0_I1228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1228_MP7 (XI0_I1228_p1 I0_two13_b3_1 XI0_I1228_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1228_MP5 (VDD I0_one13_b3_1 XI0_I1228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1228_MP10 (XI0_I1228_xan XI0_I1228_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1281_MP12 (VDD I0_B_29_b3_1 XI0_I1281_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1281_MP18 (XI0_I1281_xp1 XI0_I1281_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1281_MP20 (I0_pp14_8 I0_B_29_b3_1 XI0_I1281_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1281_MP19 (XI0_I1281_xp1 XI0_I1281_xan I0_pp14_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1281_MP17 (VDD XI0_I1281_xn XI0_I1281_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1281_MP6 (XI0_I1281_p1 I0_A_8_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1281_MP8 (XI0_I1281_xn I0_A_7_b3_5 XI0_I1281_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1281_MP7 (XI0_I1281_p1 I0_two14_b3_1 XI0_I1281_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1281_MP5 (VDD I0_one14_b3_1 XI0_I1281_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1281_MP10 (XI0_I1281_xan XI0_I1281_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1282_MP12 (VDD I0_B_29_b3_1 XI0_I1282_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1282_MP18 (XI0_I1282_xp1 XI0_I1282_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1282_MP20 (I0_pp14_9 I0_B_29_b3_1 XI0_I1282_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1282_MP19 (XI0_I1282_xp1 XI0_I1282_xan I0_pp14_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1282_MP17 (VDD XI0_I1282_xn XI0_I1282_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1282_MP6 (XI0_I1282_p1 I0_A_9_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1282_MP8 (XI0_I1282_xn I0_A_8_b3_5 XI0_I1282_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1282_MP7 (XI0_I1282_p1 I0_two14_b3_1 XI0_I1282_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1282_MP5 (VDD I0_one14_b3_1 XI0_I1282_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1282_MP10 (XI0_I1282_xan XI0_I1282_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1230_MP12 (VDD I0_B_27_b3_2 XI0_I1230_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1230_MP18 (XI0_I1230_xp1 XI0_I1230_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1230_MP20 (I0_pp13_12 I0_B_27_b3_2 XI0_I1230_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1230_MP19 (XI0_I1230_xp1 XI0_I1230_xan I0_pp13_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1230_MP17 (VDD XI0_I1230_xn XI0_I1230_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1230_MP6 (XI0_I1230_p1 I0_A_12_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1230_MP8 (XI0_I1230_xn I0_A_11_b3_5 XI0_I1230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1230_MP7 (XI0_I1230_p1 I0_two13_b3_2 XI0_I1230_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1230_MP5 (VDD I0_one13_b3_2 XI0_I1230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1230_MP10 (XI0_I1230_xan XI0_I1230_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1178_MP12 (VDD I0_B_25_b3_2 XI0_I1178_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1178_MP18 (XI0_I1178_xp1 XI0_I1178_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1178_MP20 (I0_pp12_15 I0_B_25_b3_2 XI0_I1178_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1178_MP19 (XI0_I1178_xp1 XI0_I1178_xan I0_pp12_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1178_MP17 (VDD XI0_I1178_xn XI0_I1178_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1178_MP6 (XI0_I1178_p1 I0_A_15_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1178_MP8 (XI0_I1178_xn I0_A_14_b3_4 XI0_I1178_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1178_MP7 (XI0_I1178_p1 I0_two12_b3_2 XI0_I1178_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1178_MP5 (VDD I0_one12_b3_2 XI0_I1178_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1178_MP10 (XI0_I1178_xan XI0_I1178_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1177_MP12 (VDD I0_B_25_b3_2 XI0_I1177_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1177_MP18 (XI0_I1177_xp1 XI0_I1177_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1177_MP20 (I0_pp12_14 I0_B_25_b3_2 XI0_I1177_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1177_MP19 (XI0_I1177_xp1 XI0_I1177_xan I0_pp12_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1177_MP17 (VDD XI0_I1177_xn XI0_I1177_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1177_MP6 (XI0_I1177_p1 I0_A_14_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1177_MP8 (XI0_I1177_xn I0_A_13_b3_4 XI0_I1177_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1177_MP7 (XI0_I1177_p1 I0_two12_b3_2 XI0_I1177_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1177_MP5 (VDD I0_one12_b3_2 XI0_I1177_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1177_MP10 (XI0_I1177_xan XI0_I1177_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1109_MP12 (VDD I0_B_23_b3_0 XI0_I1109_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1109_MP18 (XI0_I1109_xp1 XI0_I1109_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1109_MP20 (I0_pp11_1 I0_B_23_b3_0 XI0_I1109_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1109_MP19 (XI0_I1109_xp1 XI0_I1109_xan I0_pp11_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1109_MP17 (VDD XI0_I1109_xn XI0_I1109_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1109_MP6 (XI0_I1109_p1 I0_A_1_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1109_MP8 (XI0_I1109_xn I0_A_0_b3_4 XI0_I1109_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1109_MP7 (XI0_I1109_p1 I0_two11_b3_0 XI0_I1109_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1109_MP5 (VDD I0_one11_b3_0 XI0_I1109_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1109_MP10 (XI0_I1109_xan XI0_I1109_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1108_MP12 (VDD I0_B_23_b3_0 XI0_I1108_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1108_MP18 (XI0_I1108_xp1 XI0_I1108_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1108_MP20 (I0_pp11_0 I0_B_23_b3_0 XI0_I1108_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1108_MP19 (XI0_I1108_xp1 XI0_I1108_xan I0_pp11_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1108_MP17 (VDD XI0_I1108_xn XI0_I1108_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1108_MP6 (XI0_I1108_p1 I0_A_0_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1108_MP8 (XI0_I1108_xn VSS XI0_I1108_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1108_MP7 (XI0_I1108_p1 I0_two11_b3_0 XI0_I1108_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1108_MP5 (VDD I0_one11_b3_0 XI0_I1108_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1108_MP10 (XI0_I1108_xan XI0_I1108_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1111_MP12 (VDD I0_B_23_b3_0 XI0_I1111_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1111_MP18 (XI0_I1111_xp1 XI0_I1111_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1111_MP20 (I0_pp11_3 I0_B_23_b3_0 XI0_I1111_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1111_MP19 (XI0_I1111_xp1 XI0_I1111_xan I0_pp11_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1111_MP17 (VDD XI0_I1111_xn XI0_I1111_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1111_MP6 (XI0_I1111_p1 I0_A_3_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1111_MP8 (XI0_I1111_xn I0_A_2_b3_4 XI0_I1111_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1111_MP7 (XI0_I1111_p1 I0_two11_b3_0 XI0_I1111_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1111_MP5 (VDD I0_one11_b3_0 XI0_I1111_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1111_MP10 (XI0_I1111_xan XI0_I1111_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1169_MP12 (VDD I0_B_25_b3_1 XI0_I1169_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1169_MP18 (XI0_I1169_xp1 XI0_I1169_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1169_MP20 (I0_pp12_6 I0_B_25_b3_1 XI0_I1169_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1169_MP19 (XI0_I1169_xp1 XI0_I1169_xan I0_pp12_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1169_MP17 (VDD XI0_I1169_xn XI0_I1169_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1169_MP6 (XI0_I1169_p1 I0_A_6_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1169_MP8 (XI0_I1169_xn I0_A_5_b3_4 XI0_I1169_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1169_MP7 (XI0_I1169_p1 I0_two12_b3_1 XI0_I1169_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1169_MP5 (VDD I0_one12_b3_1 XI0_I1169_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1169_MP10 (XI0_I1169_xan XI0_I1169_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1168_MP12 (VDD I0_B_25_b3_1 XI0_I1168_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1168_MP18 (XI0_I1168_xp1 XI0_I1168_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1168_MP20 (I0_pp12_5 I0_B_25_b3_1 XI0_I1168_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1168_MP19 (XI0_I1168_xp1 XI0_I1168_xan I0_pp12_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1168_MP17 (VDD XI0_I1168_xn XI0_I1168_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1168_MP6 (XI0_I1168_p1 I0_A_5_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1168_MP8 (XI0_I1168_xn I0_A_4_b3_4 XI0_I1168_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1168_MP7 (XI0_I1168_p1 I0_two12_b3_0 XI0_I1168_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1168_MP5 (VDD I0_one12_b3_0 XI0_I1168_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1168_MP10 (XI0_I1168_xan XI0_I1168_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1224_MP12 (VDD I0_B_27_b3_1 XI0_I1224_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1224_MP18 (XI0_I1224_xp1 XI0_I1224_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1224_MP20 (I0_pp13_6 I0_B_27_b3_1 XI0_I1224_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1224_MP19 (XI0_I1224_xp1 XI0_I1224_xan I0_pp13_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1224_MP17 (VDD XI0_I1224_xn XI0_I1224_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1224_MP6 (XI0_I1224_p1 I0_A_6_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1224_MP8 (XI0_I1224_xn I0_A_5_b3_5 XI0_I1224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1224_MP7 (XI0_I1224_p1 I0_two13_b3_1 XI0_I1224_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1224_MP5 (VDD I0_one13_b3_1 XI0_I1224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1224_MP10 (XI0_I1224_xan XI0_I1224_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1279_MP12 (VDD I0_B_29_b3_1 XI0_I1279_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1279_MP18 (XI0_I1279_xp1 XI0_I1279_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1279_MP20 (I0_pp14_6 I0_B_29_b3_1 XI0_I1279_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1279_MP19 (XI0_I1279_xp1 XI0_I1279_xan I0_pp14_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1279_MP17 (VDD XI0_I1279_xn XI0_I1279_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1279_MP6 (XI0_I1279_p1 I0_A_6_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1279_MP8 (XI0_I1279_xn I0_A_5_b3_5 XI0_I1279_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1279_MP7 (XI0_I1279_p1 I0_two14_b3_1 XI0_I1279_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1279_MP5 (VDD I0_one14_b3_1 XI0_I1279_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1279_MP10 (XI0_I1279_xan XI0_I1279_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1336_MP12 (VDD I0_B_31_b3_1 XI0_I1336_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1336_MP18 (XI0_I1336_xp1 XI0_I1336_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1336_MP20 (I0_pp15_8 I0_B_31_b3_1 XI0_I1336_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1336_MP19 (XI0_I1336_xp1 XI0_I1336_xan I0_pp15_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1336_MP17 (VDD XI0_I1336_xn XI0_I1336_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1336_MP6 (XI0_I1336_p1 I0_A_8_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1336_MP8 (XI0_I1336_xn I0_A_7_b3_5 XI0_I1336_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1336_MP7 (XI0_I1336_p1 I0_two15_b3_1 XI0_I1336_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1336_MP5 (VDD I0_one15_b3_1 XI0_I1336_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1336_MP10 (XI0_I1336_xan XI0_I1336_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1337_MP12 (VDD I0_B_31_b3_1 XI0_I1337_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1337_MP18 (XI0_I1337_xp1 XI0_I1337_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1337_MP20 (I0_pp15_9 I0_B_31_b3_1 XI0_I1337_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1337_MP19 (XI0_I1337_xp1 XI0_I1337_xan I0_pp15_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1337_MP17 (VDD XI0_I1337_xn XI0_I1337_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1337_MP6 (XI0_I1337_p1 I0_A_9_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1337_MP8 (XI0_I1337_xn I0_A_8_b3_5 XI0_I1337_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1337_MP7 (XI0_I1337_p1 I0_two15_b3_1 XI0_I1337_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1337_MP5 (VDD I0_one15_b3_1 XI0_I1337_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1337_MP10 (XI0_I1337_xan XI0_I1337_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1231_MP12 (VDD I0_B_27_b3_2 XI0_I1231_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1231_MP18 (XI0_I1231_xp1 XI0_I1231_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1231_MP20 (I0_pp13_13 I0_B_27_b3_2 XI0_I1231_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1231_MP19 (XI0_I1231_xp1 XI0_I1231_xan I0_pp13_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1231_MP17 (VDD XI0_I1231_xn XI0_I1231_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1231_MP6 (XI0_I1231_p1 I0_A_13_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1231_MP8 (XI0_I1231_xn I0_A_12_b3_5 XI0_I1231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1231_MP7 (XI0_I1231_p1 I0_two13_b3_2 XI0_I1231_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1231_MP5 (VDD I0_one13_b3_2 XI0_I1231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1231_MP10 (XI0_I1231_xan XI0_I1231_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1179_MP12 (VDD I0_B_25_b3_2 XI0_I1179_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1179_MP18 (XI0_I1179_xp1 XI0_I1179_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1179_MP20 (I0_pp12_16 I0_B_25_b3_2 XI0_I1179_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1179_MP19 (XI0_I1179_xp1 XI0_I1179_xan I0_pp12_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1179_MP17 (VDD XI0_I1179_xn XI0_I1179_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1179_MP6 (XI0_I1179_p1 I0_A_16_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1179_MP8 (XI0_I1179_xn I0_A_15_b3_4 XI0_I1179_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1179_MP7 (XI0_I1179_p1 I0_two12_b3_2 XI0_I1179_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1179_MP5 (VDD I0_one12_b3_2 XI0_I1179_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1179_MP10 (XI0_I1179_xan XI0_I1179_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1163_MP12 (VDD I0_B_25_b3_0 XI0_I1163_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1163_MP18 (XI0_I1163_xp1 XI0_I1163_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1163_MP20 (I0_pp12_0 I0_B_25_b3_0 XI0_I1163_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1163_MP19 (XI0_I1163_xp1 XI0_I1163_xan I0_pp12_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1163_MP17 (VDD XI0_I1163_xn XI0_I1163_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1163_MP6 (XI0_I1163_p1 I0_A_0_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1163_MP8 (XI0_I1163_xn VSS XI0_I1163_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1163_MP7 (XI0_I1163_p1 I0_two12_b3_0 XI0_I1163_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1163_MP5 (VDD I0_one12_b3_0 XI0_I1163_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1163_MP10 (XI0_I1163_xan XI0_I1163_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1166_MP12 (VDD I0_B_25_b3_0 XI0_I1166_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1166_MP18 (XI0_I1166_xp1 XI0_I1166_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1166_MP20 (I0_pp12_3 I0_B_25_b3_0 XI0_I1166_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1166_MP19 (XI0_I1166_xp1 XI0_I1166_xan I0_pp12_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1166_MP17 (VDD XI0_I1166_xn XI0_I1166_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1166_MP6 (XI0_I1166_p1 I0_A_3_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1166_MP8 (XI0_I1166_xn I0_A_2_b3_4 XI0_I1166_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1166_MP7 (XI0_I1166_p1 I0_two12_b3_0 XI0_I1166_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1166_MP5 (VDD I0_one12_b3_0 XI0_I1166_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1166_MP10 (XI0_I1166_xan XI0_I1166_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1164_MP12 (VDD I0_B_25_b3_0 XI0_I1164_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1164_MP18 (XI0_I1164_xp1 XI0_I1164_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1164_MP20 (I0_pp12_1 I0_B_25_b3_0 XI0_I1164_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1164_MP19 (XI0_I1164_xp1 XI0_I1164_xan I0_pp12_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1164_MP17 (VDD XI0_I1164_xn XI0_I1164_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1164_MP6 (XI0_I1164_p1 I0_A_1_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1164_MP8 (XI0_I1164_xn I0_A_0_b3_4 XI0_I1164_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1164_MP7 (XI0_I1164_p1 I0_two12_b3_0 XI0_I1164_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1164_MP5 (VDD I0_one12_b3_0 XI0_I1164_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1164_MP10 (XI0_I1164_xan XI0_I1164_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1165_MP12 (VDD I0_B_25_b3_0 XI0_I1165_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1165_MP18 (XI0_I1165_xp1 XI0_I1165_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1165_MP20 (I0_pp12_2 I0_B_25_b3_0 XI0_I1165_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1165_MP19 (XI0_I1165_xp1 XI0_I1165_xan I0_pp12_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1165_MP17 (VDD XI0_I1165_xn XI0_I1165_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1165_MP6 (XI0_I1165_p1 I0_A_2_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1165_MP8 (XI0_I1165_xn I0_A_1_b3_4 XI0_I1165_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1165_MP7 (XI0_I1165_p1 I0_two12_b3_0 XI0_I1165_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1165_MP5 (VDD I0_one12_b3_0 XI0_I1165_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1165_MP10 (XI0_I1165_xan XI0_I1165_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1221_MP12 (VDD I0_B_27_b3_0 XI0_I1221_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1221_MP18 (XI0_I1221_xp1 XI0_I1221_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1221_MP20 (I0_pp13_3 I0_B_27_b3_0 XI0_I1221_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1221_MP19 (XI0_I1221_xp1 XI0_I1221_xan I0_pp13_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1221_MP17 (VDD XI0_I1221_xn XI0_I1221_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1221_MP6 (XI0_I1221_p1 I0_A_3_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1221_MP8 (XI0_I1221_xn I0_A_2_b3_5 XI0_I1221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1221_MP7 (XI0_I1221_p1 I0_two13_b3_0 XI0_I1221_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1221_MP5 (VDD I0_one13_b3_0 XI0_I1221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1221_MP10 (XI0_I1221_xan XI0_I1221_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1167_MP12 (VDD I0_B_25_b3_0 XI0_I1167_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1167_MP18 (XI0_I1167_xp1 XI0_I1167_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1167_MP20 (I0_pp12_4 I0_B_25_b3_0 XI0_I1167_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1167_MP19 (XI0_I1167_xp1 XI0_I1167_xan I0_pp12_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1167_MP17 (VDD XI0_I1167_xn XI0_I1167_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1167_MP6 (XI0_I1167_p1 I0_A_4_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1167_MP8 (XI0_I1167_xn I0_A_3_b3_4 XI0_I1167_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1167_MP7 (XI0_I1167_p1 I0_two12_b3_0 XI0_I1167_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1167_MP5 (VDD I0_one12_b3_0 XI0_I1167_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1167_MP10 (XI0_I1167_xan XI0_I1167_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1334_MP12 (VDD I0_B_31_b3_1 XI0_I1334_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1334_MP18 (XI0_I1334_xp1 XI0_I1334_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1334_MP20 (I0_pp15_6 I0_B_31_b3_1 XI0_I1334_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1334_MP19 (XI0_I1334_xp1 XI0_I1334_xan I0_pp15_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1334_MP17 (VDD XI0_I1334_xn XI0_I1334_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1334_MP6 (XI0_I1334_p1 I0_A_6_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1334_MP8 (XI0_I1334_xn I0_A_5_b3_5 XI0_I1334_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1334_MP7 (XI0_I1334_p1 I0_two15_b3_1 XI0_I1334_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1334_MP5 (VDD I0_one15_b3_1 XI0_I1334_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1334_MP10 (XI0_I1334_xan XI0_I1334_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1335_MP12 (VDD I0_B_31_b3_1 XI0_I1335_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1335_MP18 (XI0_I1335_xp1 XI0_I1335_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1335_MP20 (I0_pp15_7 I0_B_31_b3_1 XI0_I1335_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1335_MP19 (XI0_I1335_xp1 XI0_I1335_xan I0_pp15_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1335_MP17 (VDD XI0_I1335_xn XI0_I1335_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1335_MP6 (XI0_I1335_p1 I0_A_7_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1335_MP8 (XI0_I1335_xn I0_A_6_b3_5 XI0_I1335_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1335_MP7 (XI0_I1335_p1 I0_two15_b3_1 XI0_I1335_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1335_MP5 (VDD I0_one15_b3_1 XI0_I1335_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1335_MP10 (XI0_I1335_xan XI0_I1335_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1338_MP12 (VDD I0_B_31_b3_1 XI0_I1338_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1338_MP18 (XI0_I1338_xp1 XI0_I1338_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1338_MP20 (I0_pp15_10 I0_B_31_b3_1 XI0_I1338_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1338_MP19 (XI0_I1338_xp1 XI0_I1338_xan I0_pp15_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1338_MP17 (VDD XI0_I1338_xn XI0_I1338_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1338_MP6 (XI0_I1338_p1 I0_A_10_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1338_MP8 (XI0_I1338_xn I0_A_9_b3_5 XI0_I1338_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1338_MP7 (XI0_I1338_p1 I0_two15_b3_1 XI0_I1338_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1338_MP5 (VDD I0_one15_b3_1 XI0_I1338_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1338_MP10 (XI0_I1338_xan XI0_I1338_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1233_MP12 (VDD I0_B_27_b3_2 XI0_I1233_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1233_MP18 (XI0_I1233_xp1 XI0_I1233_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1233_MP20 (I0_pp13_15 I0_B_27_b3_2 XI0_I1233_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1233_MP19 (XI0_I1233_xp1 XI0_I1233_xan I0_pp13_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1233_MP17 (VDD XI0_I1233_xn XI0_I1233_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1233_MP6 (XI0_I1233_p1 I0_A_15_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1233_MP8 (XI0_I1233_xn I0_A_14_b3_5 XI0_I1233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1233_MP7 (XI0_I1233_p1 I0_two13_b3_2 XI0_I1233_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1233_MP5 (VDD I0_one13_b3_2 XI0_I1233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1233_MP10 (XI0_I1233_xan XI0_I1233_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1232_MP12 (VDD I0_B_27_b3_2 XI0_I1232_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1232_MP18 (XI0_I1232_xp1 XI0_I1232_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1232_MP20 (I0_pp13_14 I0_B_27_b3_2 XI0_I1232_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1232_MP19 (XI0_I1232_xp1 XI0_I1232_xan I0_pp13_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1232_MP17 (VDD XI0_I1232_xn XI0_I1232_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1232_MP6 (XI0_I1232_p1 I0_A_14_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1232_MP8 (XI0_I1232_xn I0_A_13_b3_5 XI0_I1232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1232_MP7 (XI0_I1232_p1 I0_two13_b3_2 XI0_I1232_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1232_MP5 (VDD I0_one13_b3_2 XI0_I1232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1232_MP10 (XI0_I1232_xan XI0_I1232_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I965_MP12 (VDD I0_B_17_b3_3 XI0_I965_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I965_MP18 (XI0_I965_xp1 XI0_I965_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I965_MP20 (I0_pp8_22 I0_B_17_b3_3 XI0_I965_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I965_MP19 (XI0_I965_xp1 XI0_I965_xan I0_pp8_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I965_MP17 (VDD XI0_I965_xn XI0_I965_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I965_MP6 (XI0_I965_p1 I0_A_22_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I965_MP8 (XI0_I965_xn I0_A_21_b3_3 XI0_I965_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I965_MP7 (XI0_I965_p1 I0_two8_b3_4 XI0_I965_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I965_MP5 (VDD I0_one8_b3_4 XI0_I965_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I965_MP10 (XI0_I965_xan XI0_I965_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1020_MP12 (VDD I0_B_19_b3_3 XI0_I1020_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1020_MP18 (XI0_I1020_xp1 XI0_I1020_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1020_MP20 (I0_pp9_22 I0_B_19_b3_3 XI0_I1020_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1020_MP19 (XI0_I1020_xp1 XI0_I1020_xan I0_pp9_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1020_MP17 (VDD XI0_I1020_xn XI0_I1020_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1020_MP6 (XI0_I1020_p1 I0_A_22_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1020_MP8 (XI0_I1020_xn I0_A_21_b3_3 XI0_I1020_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1020_MP7 (XI0_I1020_p1 I0_two9_b3_4 XI0_I1020_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1020_MP5 (VDD I0_one9_b3_4 XI0_I1020_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1020_MP10 (XI0_I1020_xan XI0_I1020_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1218_MP12 (VDD I0_B_27_b3_0 XI0_I1218_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1218_MP18 (XI0_I1218_xp1 XI0_I1218_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1218_MP20 (I0_pp13_0 I0_B_27_b3_0 XI0_I1218_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1218_MP19 (XI0_I1218_xp1 XI0_I1218_xan I0_pp13_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1218_MP17 (VDD XI0_I1218_xn XI0_I1218_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1218_MP6 (XI0_I1218_p1 I0_A_0_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1218_MP8 (XI0_I1218_xn VSS XI0_I1218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1218_MP7 (XI0_I1218_p1 I0_two13_b3_0 XI0_I1218_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1218_MP5 (VDD I0_one13_b3_0 XI0_I1218_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1218_MP10 (XI0_I1218_xan XI0_I1218_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1219_MP12 (VDD I0_B_27_b3_0 XI0_I1219_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1219_MP18 (XI0_I1219_xp1 XI0_I1219_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1219_MP20 (I0_pp13_1 I0_B_27_b3_0 XI0_I1219_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1219_MP19 (XI0_I1219_xp1 XI0_I1219_xan I0_pp13_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1219_MP17 (VDD XI0_I1219_xn XI0_I1219_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1219_MP6 (XI0_I1219_p1 I0_A_1_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1219_MP8 (XI0_I1219_xn I0_A_0_b3_5 XI0_I1219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1219_MP7 (XI0_I1219_p1 I0_two13_b3_0 XI0_I1219_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1219_MP5 (VDD I0_one13_b3_0 XI0_I1219_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1219_MP10 (XI0_I1219_xan XI0_I1219_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1222_MP12 (VDD I0_B_27_b3_0 XI0_I1222_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1222_MP18 (XI0_I1222_xp1 XI0_I1222_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1222_MP20 (I0_pp13_4 I0_B_27_b3_0 XI0_I1222_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1222_MP19 (XI0_I1222_xp1 XI0_I1222_xan I0_pp13_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1222_MP17 (VDD XI0_I1222_xn XI0_I1222_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1222_MP6 (XI0_I1222_p1 I0_A_4_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1222_MP8 (XI0_I1222_xn I0_A_3_b3_5 XI0_I1222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1222_MP7 (XI0_I1222_p1 I0_two13_b3_0 XI0_I1222_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1222_MP5 (VDD I0_one13_b3_0 XI0_I1222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1222_MP10 (XI0_I1222_xan XI0_I1222_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1220_MP12 (VDD I0_B_27_b3_0 XI0_I1220_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1220_MP18 (XI0_I1220_xp1 XI0_I1220_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1220_MP20 (I0_pp13_2 I0_B_27_b3_0 XI0_I1220_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1220_MP19 (XI0_I1220_xp1 XI0_I1220_xan I0_pp13_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1220_MP17 (VDD XI0_I1220_xn XI0_I1220_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1220_MP6 (XI0_I1220_p1 I0_A_2_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1220_MP8 (XI0_I1220_xn I0_A_1_b3_5 XI0_I1220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1220_MP7 (XI0_I1220_p1 I0_two13_b3_0 XI0_I1220_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1220_MP5 (VDD I0_one13_b3_0 XI0_I1220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1220_MP10 (XI0_I1220_xan XI0_I1220_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1274_MP12 (VDD I0_B_29_b3_0 XI0_I1274_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1274_MP18 (XI0_I1274_xp1 XI0_I1274_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1274_MP20 (I0_pp14_1 I0_B_29_b3_0 XI0_I1274_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1274_MP19 (XI0_I1274_xp1 XI0_I1274_xan I0_pp14_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1274_MP17 (VDD XI0_I1274_xn XI0_I1274_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1274_MP6 (XI0_I1274_p1 I0_A_1_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1274_MP8 (XI0_I1274_xn I0_A_0_b3_5 XI0_I1274_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1274_MP7 (XI0_I1274_p1 I0_two14_b3_0 XI0_I1274_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1274_MP5 (VDD I0_one14_b3_0 XI0_I1274_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1274_MP10 (XI0_I1274_xan XI0_I1274_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1223_MP12 (VDD I0_B_27_b3_1 XI0_I1223_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1223_MP18 (XI0_I1223_xp1 XI0_I1223_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1223_MP20 (I0_pp13_5 I0_B_27_b3_1 XI0_I1223_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1223_MP19 (XI0_I1223_xp1 XI0_I1223_xan I0_pp13_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1223_MP17 (VDD XI0_I1223_xn XI0_I1223_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1223_MP6 (XI0_I1223_p1 I0_A_5_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1223_MP8 (XI0_I1223_xn I0_A_4_b3_5 XI0_I1223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1223_MP7 (XI0_I1223_p1 I0_two13_b3_0 XI0_I1223_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1223_MP5 (VDD I0_one13_b3_0 XI0_I1223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1223_MP10 (XI0_I1223_xan XI0_I1223_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1330_MP12 (VDD I0_B_31_b3_0 XI0_I1330_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1330_MP18 (XI0_I1330_xp1 XI0_I1330_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1330_MP20 (I0_pp15_2 I0_B_31_b3_0 XI0_I1330_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1330_MP19 (XI0_I1330_xp1 XI0_I1330_xan I0_pp15_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1330_MP17 (VDD XI0_I1330_xn XI0_I1330_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1330_MP6 (XI0_I1330_p1 I0_A_2_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1330_MP8 (XI0_I1330_xn I0_A_1_b3_5 XI0_I1330_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1330_MP7 (XI0_I1330_p1 I0_two15_b3_0 XI0_I1330_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1330_MP5 (VDD I0_one15_b3_0 XI0_I1330_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1330_MP10 (XI0_I1330_xan XI0_I1330_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1278_MP12 (VDD I0_B_29_b3_1 XI0_I1278_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1278_MP18 (XI0_I1278_xp1 XI0_I1278_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1278_MP20 (I0_pp14_5 I0_B_29_b3_1 XI0_I1278_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1278_MP19 (XI0_I1278_xp1 XI0_I1278_xan I0_pp14_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1278_MP17 (VDD XI0_I1278_xn XI0_I1278_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1278_MP6 (XI0_I1278_p1 I0_A_5_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1278_MP8 (XI0_I1278_xn I0_A_4_b3_5 XI0_I1278_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1278_MP7 (XI0_I1278_p1 I0_two14_b3_0 XI0_I1278_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1278_MP5 (VDD I0_one14_b3_0 XI0_I1278_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1278_MP10 (XI0_I1278_xan XI0_I1278_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1277_MP12 (VDD I0_B_29_b3_0 XI0_I1277_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1277_MP18 (XI0_I1277_xp1 XI0_I1277_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1277_MP20 (I0_pp14_4 I0_B_29_b3_0 XI0_I1277_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1277_MP19 (XI0_I1277_xp1 XI0_I1277_xan I0_pp14_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1277_MP17 (VDD XI0_I1277_xn XI0_I1277_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1277_MP6 (XI0_I1277_p1 I0_A_4_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1277_MP8 (XI0_I1277_xn I0_A_3_b3_5 XI0_I1277_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1277_MP7 (XI0_I1277_p1 I0_two14_b3_0 XI0_I1277_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1277_MP5 (VDD I0_one14_b3_0 XI0_I1277_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1277_MP10 (XI0_I1277_xan XI0_I1277_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1333_MP12 (VDD I0_B_31_b3_1 XI0_I1333_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1333_MP18 (XI0_I1333_xp1 XI0_I1333_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1333_MP20 (I0_pp15_5 I0_B_31_b3_1 XI0_I1333_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1333_MP19 (XI0_I1333_xp1 XI0_I1333_xan I0_pp15_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1333_MP17 (VDD XI0_I1333_xn XI0_I1333_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1333_MP6 (XI0_I1333_p1 I0_A_5_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1333_MP8 (XI0_I1333_xn I0_A_4_b3_5 XI0_I1333_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1333_MP7 (XI0_I1333_p1 I0_two15_b3_0 XI0_I1333_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1333_MP5 (VDD I0_one15_b3_0 XI0_I1333_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1333_MP10 (XI0_I1333_xan XI0_I1333_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1332_MP12 (VDD I0_B_31_b3_0 XI0_I1332_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1332_MP18 (XI0_I1332_xp1 XI0_I1332_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1332_MP20 (I0_pp15_4 I0_B_31_b3_0 XI0_I1332_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1332_MP19 (XI0_I1332_xp1 XI0_I1332_xan I0_pp15_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1332_MP17 (VDD XI0_I1332_xn XI0_I1332_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1332_MP6 (XI0_I1332_p1 I0_A_4_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1332_MP8 (XI0_I1332_xn I0_A_3_b3_5 XI0_I1332_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1332_MP7 (XI0_I1332_p1 I0_two15_b3_0 XI0_I1332_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1332_MP5 (VDD I0_one15_b3_0 XI0_I1332_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1332_MP10 (XI0_I1332_xan XI0_I1332_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1284_MP12 (VDD I0_B_29_b3_2 XI0_I1284_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1284_MP18 (XI0_I1284_xp1 XI0_I1284_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1284_MP20 (I0_pp14_11 I0_B_29_b3_2 XI0_I1284_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1284_MP19 (XI0_I1284_xp1 XI0_I1284_xan I0_pp14_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1284_MP17 (VDD XI0_I1284_xn XI0_I1284_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1284_MP6 (XI0_I1284_p1 I0_A_11_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1284_MP8 (XI0_I1284_xn I0_A_10_b3_5 XI0_I1284_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1284_MP7 (XI0_I1284_p1 I0_two14_b3_2 XI0_I1284_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1284_MP5 (VDD I0_one14_b3_2 XI0_I1284_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1284_MP10 (XI0_I1284_xan XI0_I1284_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1285_MP12 (VDD I0_B_29_b3_2 XI0_I1285_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1285_MP18 (XI0_I1285_xp1 XI0_I1285_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1285_MP20 (I0_pp14_12 I0_B_29_b3_2 XI0_I1285_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1285_MP19 (XI0_I1285_xp1 XI0_I1285_xan I0_pp14_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1285_MP17 (VDD XI0_I1285_xn XI0_I1285_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1285_MP6 (XI0_I1285_p1 I0_A_12_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1285_MP8 (XI0_I1285_xn I0_A_11_b3_5 XI0_I1285_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1285_MP7 (XI0_I1285_p1 I0_two14_b3_2 XI0_I1285_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1285_MP5 (VDD I0_one14_b3_2 XI0_I1285_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1285_MP10 (XI0_I1285_xan XI0_I1285_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1234_MP12 (VDD I0_B_27_b3_2 XI0_I1234_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1234_MP18 (XI0_I1234_xp1 XI0_I1234_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1234_MP20 (I0_pp13_16 I0_B_27_b3_2 XI0_I1234_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1234_MP19 (XI0_I1234_xp1 XI0_I1234_xan I0_pp13_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1234_MP17 (VDD XI0_I1234_xn XI0_I1234_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1234_MP6 (XI0_I1234_p1 I0_A_16_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1234_MP8 (XI0_I1234_xn I0_A_15_b3_5 XI0_I1234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1234_MP7 (XI0_I1234_p1 I0_two13_b3_2 XI0_I1234_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1234_MP5 (VDD I0_one13_b3_2 XI0_I1234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1234_MP10 (XI0_I1234_xan XI0_I1234_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I966_MP12 (VDD I0_B_17_b3_4 XI0_I966_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I966_MP18 (XI0_I966_xp1 XI0_I966_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I966_MP20 (I0_pp8_23 I0_B_17_b3_4 XI0_I966_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I966_MP19 (XI0_I966_xp1 XI0_I966_xan I0_pp8_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I966_MP17 (VDD XI0_I966_xn XI0_I966_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I966_MP6 (XI0_I966_p1 I0_A_23_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I966_MP8 (XI0_I966_xn I0_A_22_b3_3 XI0_I966_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I966_MP7 (XI0_I966_p1 I0_two8_b3_4 XI0_I966_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I966_MP5 (VDD I0_one8_b3_4 XI0_I966_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I966_MP10 (XI0_I966_xan XI0_I966_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1021_MP12 (VDD I0_B_19_b3_4 XI0_I1021_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1021_MP18 (XI0_I1021_xp1 XI0_I1021_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1021_MP20 (I0_pp9_23 I0_B_19_b3_4 XI0_I1021_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1021_MP19 (XI0_I1021_xp1 XI0_I1021_xan I0_pp9_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1021_MP17 (VDD XI0_I1021_xn XI0_I1021_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1021_MP6 (XI0_I1021_p1 I0_A_23_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1021_MP8 (XI0_I1021_xn I0_A_22_b3_3 XI0_I1021_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1021_MP7 (XI0_I1021_p1 I0_two9_b3_4 XI0_I1021_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1021_MP5 (VDD I0_one9_b3_4 XI0_I1021_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1021_MP10 (XI0_I1021_xan XI0_I1021_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1329_MP12 (VDD I0_B_31_b3_0 XI0_I1329_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1329_MP18 (XI0_I1329_xp1 XI0_I1329_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1329_MP20 (I0_pp15_1 I0_B_31_b3_0 XI0_I1329_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1329_MP19 (XI0_I1329_xp1 XI0_I1329_xan I0_pp15_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1329_MP17 (VDD XI0_I1329_xn XI0_I1329_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1329_MP6 (XI0_I1329_p1 I0_A_1_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1329_MP8 (XI0_I1329_xn I0_A_0_b3_5 XI0_I1329_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1329_MP7 (XI0_I1329_p1 I0_two15_b3_0 XI0_I1329_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1329_MP5 (VDD I0_one15_b3_0 XI0_I1329_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1329_MP10 (XI0_I1329_xan XI0_I1329_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1273_MP12 (VDD I0_B_29_b3_0 XI0_I1273_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1273_MP18 (XI0_I1273_xp1 XI0_I1273_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1273_MP20 (I0_pp14_0 I0_B_29_b3_0 XI0_I1273_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1273_MP19 (XI0_I1273_xp1 XI0_I1273_xan I0_pp14_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1273_MP17 (VDD XI0_I1273_xn XI0_I1273_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1273_MP6 (XI0_I1273_p1 I0_A_0_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1273_MP8 (XI0_I1273_xn VSS XI0_I1273_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1273_MP7 (XI0_I1273_p1 I0_two14_b3_0 XI0_I1273_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1273_MP5 (VDD I0_one14_b3_0 XI0_I1273_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1273_MP10 (XI0_I1273_xan XI0_I1273_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1275_MP12 (VDD I0_B_29_b3_0 XI0_I1275_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1275_MP18 (XI0_I1275_xp1 XI0_I1275_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1275_MP20 (I0_pp14_2 I0_B_29_b3_0 XI0_I1275_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1275_MP19 (XI0_I1275_xp1 XI0_I1275_xan I0_pp14_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1275_MP17 (VDD XI0_I1275_xn XI0_I1275_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1275_MP6 (XI0_I1275_p1 I0_A_2_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1275_MP8 (XI0_I1275_xn I0_A_1_b3_5 XI0_I1275_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1275_MP7 (XI0_I1275_p1 I0_two14_b3_0 XI0_I1275_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1275_MP5 (VDD I0_one14_b3_0 XI0_I1275_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1275_MP10 (XI0_I1275_xan XI0_I1275_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1328_MP12 (VDD I0_B_31_b3_0 XI0_I1328_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1328_MP18 (XI0_I1328_xp1 XI0_I1328_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1328_MP20 (I0_pp15_0 I0_B_31_b3_0 XI0_I1328_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1328_MP19 (XI0_I1328_xp1 XI0_I1328_xan I0_pp15_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1328_MP17 (VDD XI0_I1328_xn XI0_I1328_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1328_MP6 (XI0_I1328_p1 I0_A_0_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1328_MP8 (XI0_I1328_xn VSS XI0_I1328_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1328_MP7 (XI0_I1328_p1 I0_two15_b3_0 XI0_I1328_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1328_MP5 (VDD I0_one15_b3_0 XI0_I1328_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1328_MP10 (XI0_I1328_xan XI0_I1328_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1276_MP12 (VDD I0_B_29_b3_0 XI0_I1276_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1276_MP18 (XI0_I1276_xp1 XI0_I1276_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1276_MP20 (I0_pp14_3 I0_B_29_b3_0 XI0_I1276_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1276_MP19 (XI0_I1276_xp1 XI0_I1276_xan I0_pp14_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1276_MP17 (VDD XI0_I1276_xn XI0_I1276_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1276_MP6 (XI0_I1276_p1 I0_A_3_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1276_MP8 (XI0_I1276_xn I0_A_2_b3_5 XI0_I1276_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1276_MP7 (XI0_I1276_p1 I0_two14_b3_0 XI0_I1276_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1276_MP5 (VDD I0_one14_b3_0 XI0_I1276_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1276_MP10 (XI0_I1276_xan XI0_I1276_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1331_MP12 (VDD I0_B_31_b3_0 XI0_I1331_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1331_MP18 (XI0_I1331_xp1 XI0_I1331_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1331_MP20 (I0_pp15_3 I0_B_31_b3_0 XI0_I1331_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1331_MP19 (XI0_I1331_xp1 XI0_I1331_xan I0_pp15_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1331_MP17 (VDD XI0_I1331_xn XI0_I1331_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1331_MP6 (XI0_I1331_p1 I0_A_3_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1331_MP8 (XI0_I1331_xn I0_A_2_b3_5 XI0_I1331_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1331_MP7 (XI0_I1331_p1 I0_two15_b3_0 XI0_I1331_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1331_MP5 (VDD I0_one15_b3_0 XI0_I1331_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1331_MP10 (XI0_I1331_xan XI0_I1331_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1340_MP12 (VDD I0_B_31_b3_2 XI0_I1340_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1340_MP18 (XI0_I1340_xp1 XI0_I1340_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1340_MP20 (I0_pp15_12 I0_B_31_b3_2 XI0_I1340_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1340_MP19 (XI0_I1340_xp1 XI0_I1340_xan I0_pp15_12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1340_MP17 (VDD XI0_I1340_xn XI0_I1340_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1340_MP6 (XI0_I1340_p1 I0_A_12_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1340_MP8 (XI0_I1340_xn I0_A_11_b3_5 XI0_I1340_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1340_MP7 (XI0_I1340_p1 I0_two15_b3_2 XI0_I1340_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1340_MP5 (VDD I0_one15_b3_2 XI0_I1340_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1340_MP10 (XI0_I1340_xan XI0_I1340_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1339_MP12 (VDD I0_B_31_b3_2 XI0_I1339_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1339_MP18 (XI0_I1339_xp1 XI0_I1339_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1339_MP20 (I0_pp15_11 I0_B_31_b3_2 XI0_I1339_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1339_MP19 (XI0_I1339_xp1 XI0_I1339_xan I0_pp15_11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1339_MP17 (VDD XI0_I1339_xn XI0_I1339_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1339_MP6 (XI0_I1339_p1 I0_A_11_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1339_MP8 (XI0_I1339_xn I0_A_10_b3_5 XI0_I1339_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1339_MP7 (XI0_I1339_p1 I0_two15_b3_2 XI0_I1339_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1339_MP5 (VDD I0_one15_b3_2 XI0_I1339_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1339_MP10 (XI0_I1339_xan XI0_I1339_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1286_MP12 (VDD I0_B_29_b3_2 XI0_I1286_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1286_MP18 (XI0_I1286_xp1 XI0_I1286_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1286_MP20 (I0_pp14_13 I0_B_29_b3_2 XI0_I1286_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1286_MP19 (XI0_I1286_xp1 XI0_I1286_xan I0_pp14_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1286_MP17 (VDD XI0_I1286_xn XI0_I1286_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1286_MP6 (XI0_I1286_p1 I0_A_13_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1286_MP8 (XI0_I1286_xn I0_A_12_b3_5 XI0_I1286_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1286_MP7 (XI0_I1286_p1 I0_two14_b3_2 XI0_I1286_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1286_MP5 (VDD I0_one14_b3_2 XI0_I1286_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1286_MP10 (XI0_I1286_xan XI0_I1286_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I967_MP12 (VDD I0_B_17_b3_4 XI0_I967_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I967_MP18 (XI0_I967_xp1 XI0_I967_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I967_MP20 (I0_pp8_24 I0_B_17_b3_4 XI0_I967_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I967_MP19 (XI0_I967_xp1 XI0_I967_xan I0_pp8_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I967_MP17 (VDD XI0_I967_xn XI0_I967_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I967_MP6 (XI0_I967_p1 I0_A_24_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I967_MP8 (XI0_I967_xn I0_A_23_b3_3 XI0_I967_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I967_MP7 (XI0_I967_p1 I0_two8_b3_4 XI0_I967_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I967_MP5 (VDD I0_one8_b3_4 XI0_I967_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I967_MP10 (XI0_I967_xan XI0_I967_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1289_MP12 (VDD I0_B_29_b3_2 XI0_I1289_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1289_MP18 (XI0_I1289_xp1 XI0_I1289_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1289_MP20 (I0_pp14_16 I0_B_29_b3_2 XI0_I1289_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1289_MP19 (XI0_I1289_xp1 XI0_I1289_xan I0_pp14_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1289_MP17 (VDD XI0_I1289_xn XI0_I1289_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1289_MP6 (XI0_I1289_p1 I0_A_16_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1289_MP8 (XI0_I1289_xn I0_A_15_b3_5 XI0_I1289_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1289_MP7 (XI0_I1289_p1 I0_two14_b3_2 XI0_I1289_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1289_MP5 (VDD I0_one14_b3_2 XI0_I1289_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1289_MP10 (XI0_I1289_xan XI0_I1289_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1288_MP12 (VDD I0_B_29_b3_2 XI0_I1288_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1288_MP18 (XI0_I1288_xp1 XI0_I1288_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1288_MP20 (I0_pp14_15 I0_B_29_b3_2 XI0_I1288_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1288_MP19 (XI0_I1288_xp1 XI0_I1288_xan I0_pp14_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1288_MP17 (VDD XI0_I1288_xn XI0_I1288_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1288_MP6 (XI0_I1288_p1 I0_A_15_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1288_MP8 (XI0_I1288_xn I0_A_14_b3_5 XI0_I1288_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1288_MP7 (XI0_I1288_p1 I0_two14_b3_2 XI0_I1288_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1288_MP5 (VDD I0_one14_b3_2 XI0_I1288_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1288_MP10 (XI0_I1288_xan XI0_I1288_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1341_MP12 (VDD I0_B_31_b3_2 XI0_I1341_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1341_MP18 (XI0_I1341_xp1 XI0_I1341_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1341_MP20 (I0_pp15_13 I0_B_31_b3_2 XI0_I1341_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1341_MP19 (XI0_I1341_xp1 XI0_I1341_xan I0_pp15_13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1341_MP17 (VDD XI0_I1341_xn XI0_I1341_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1341_MP6 (XI0_I1341_p1 I0_A_13_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1341_MP8 (XI0_I1341_xn I0_A_12_b3_5 XI0_I1341_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1341_MP7 (XI0_I1341_p1 I0_two15_b3_2 XI0_I1341_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1341_MP5 (VDD I0_one15_b3_2 XI0_I1341_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1341_MP10 (XI0_I1341_xan XI0_I1341_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1287_MP12 (VDD I0_B_29_b3_2 XI0_I1287_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1287_MP18 (XI0_I1287_xp1 XI0_I1287_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1287_MP20 (I0_pp14_14 I0_B_29_b3_2 XI0_I1287_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1287_MP19 (XI0_I1287_xp1 XI0_I1287_xan I0_pp14_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1287_MP17 (VDD XI0_I1287_xn XI0_I1287_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1287_MP6 (XI0_I1287_p1 I0_A_14_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1287_MP8 (XI0_I1287_xn I0_A_13_b3_5 XI0_I1287_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1287_MP7 (XI0_I1287_p1 I0_two14_b3_2 XI0_I1287_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1287_MP5 (VDD I0_one14_b3_2 XI0_I1287_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1287_MP10 (XI0_I1287_xan XI0_I1287_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1075_MP12 (VDD I0_B_21_b3_3 XI0_I1075_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1075_MP18 (XI0_I1075_xp1 XI0_I1075_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1075_MP20 (I0_pp10_22 I0_B_21_b3_3 XI0_I1075_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1075_MP19 (XI0_I1075_xp1 XI0_I1075_xan I0_pp10_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1075_MP17 (VDD XI0_I1075_xn XI0_I1075_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1075_MP6 (XI0_I1075_p1 I0_A_22_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1075_MP8 (XI0_I1075_xn I0_A_21_b3_3 XI0_I1075_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1075_MP7 (XI0_I1075_p1 I0_two10_b3_4 XI0_I1075_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1075_MP5 (VDD I0_one10_b3_4 XI0_I1075_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1075_MP10 (XI0_I1075_xan XI0_I1075_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I968_MP12 (VDD I0_B_17_b3_4 XI0_I968_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I968_MP18 (XI0_I968_xp1 XI0_I968_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I968_MP20 (I0_pp8_25 I0_B_17_b3_4 XI0_I968_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I968_MP19 (XI0_I968_xp1 XI0_I968_xan I0_pp8_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I968_MP17 (VDD XI0_I968_xn XI0_I968_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I968_MP6 (XI0_I968_p1 I0_A_25_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I968_MP8 (XI0_I968_xn I0_A_24_b3_3 XI0_I968_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I968_MP7 (XI0_I968_p1 I0_two8_b3_4 XI0_I968_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I968_MP5 (VDD I0_one8_b3_4 XI0_I968_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I968_MP10 (XI0_I968_xan XI0_I968_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1022_MP12 (VDD I0_B_19_b3_4 XI0_I1022_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1022_MP18 (XI0_I1022_xp1 XI0_I1022_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1022_MP20 (I0_pp9_24 I0_B_19_b3_4 XI0_I1022_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1022_MP19 (XI0_I1022_xp1 XI0_I1022_xan I0_pp9_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1022_MP17 (VDD XI0_I1022_xn XI0_I1022_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1022_MP6 (XI0_I1022_p1 I0_A_24_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1022_MP8 (XI0_I1022_xn I0_A_23_b3_3 XI0_I1022_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1022_MP7 (XI0_I1022_p1 I0_two9_b3_4 XI0_I1022_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1022_MP5 (VDD I0_one9_b3_4 XI0_I1022_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1022_MP10 (XI0_I1022_xan XI0_I1022_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1344_MP12 (VDD I0_B_31_b3_2 XI0_I1344_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1344_MP18 (XI0_I1344_xp1 XI0_I1344_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1344_MP20 (I0_pp15_16 I0_B_31_b3_2 XI0_I1344_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1344_MP19 (XI0_I1344_xp1 XI0_I1344_xan I0_pp15_16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1344_MP17 (VDD XI0_I1344_xn XI0_I1344_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1344_MP6 (XI0_I1344_p1 I0_A_16_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1344_MP8 (XI0_I1344_xn I0_A_15_b3_5 XI0_I1344_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1344_MP7 (XI0_I1344_p1 I0_two15_b3_2 XI0_I1344_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1344_MP5 (VDD I0_one15_b3_2 XI0_I1344_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1344_MP10 (XI0_I1344_xan XI0_I1344_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1343_MP12 (VDD I0_B_31_b3_2 XI0_I1343_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1343_MP18 (XI0_I1343_xp1 XI0_I1343_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1343_MP20 (I0_pp15_15 I0_B_31_b3_2 XI0_I1343_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1343_MP19 (XI0_I1343_xp1 XI0_I1343_xan I0_pp15_15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1343_MP17 (VDD XI0_I1343_xn XI0_I1343_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1343_MP6 (XI0_I1343_p1 I0_A_15_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1343_MP8 (XI0_I1343_xn I0_A_14_b3_5 XI0_I1343_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1343_MP7 (XI0_I1343_p1 I0_two15_b3_2 XI0_I1343_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1343_MP5 (VDD I0_one15_b3_2 XI0_I1343_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1343_MP10 (XI0_I1343_xan XI0_I1343_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1342_MP12 (VDD I0_B_31_b3_2 XI0_I1342_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1342_MP18 (XI0_I1342_xp1 XI0_I1342_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1342_MP20 (I0_pp15_14 I0_B_31_b3_2 XI0_I1342_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1342_MP19 (XI0_I1342_xp1 XI0_I1342_xan I0_pp15_14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1342_MP17 (VDD XI0_I1342_xn XI0_I1342_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1342_MP6 (XI0_I1342_p1 I0_A_14_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1342_MP8 (XI0_I1342_xn I0_A_13_b3_5 XI0_I1342_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1342_MP7 (XI0_I1342_p1 I0_two15_b3_2 XI0_I1342_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1342_MP5 (VDD I0_one15_b3_2 XI0_I1342_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1342_MP10 (XI0_I1342_xan XI0_I1342_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1077_MP12 (VDD I0_B_21_b3_4 XI0_I1077_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1077_MP18 (XI0_I1077_xp1 XI0_I1077_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1077_MP20 (I0_pp10_24 I0_B_21_b3_4 XI0_I1077_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1077_MP19 (XI0_I1077_xp1 XI0_I1077_xan I0_pp10_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1077_MP17 (VDD XI0_I1077_xn XI0_I1077_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1077_MP6 (XI0_I1077_p1 I0_A_24_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1077_MP8 (XI0_I1077_xn I0_A_23_b3_3 XI0_I1077_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1077_MP7 (XI0_I1077_p1 I0_two10_b3_4 XI0_I1077_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1077_MP5 (VDD I0_one10_b3_4 XI0_I1077_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1077_MP10 (XI0_I1077_xan XI0_I1077_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I970_MP12 (VDD I0_B_17_b3_4 XI0_I970_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I970_MP18 (XI0_I970_xp1 XI0_I970_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I970_MP20 (I0_pp8_27 I0_B_17_b3_4 XI0_I970_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I970_MP19 (XI0_I970_xp1 XI0_I970_xan I0_pp8_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I970_MP17 (VDD XI0_I970_xn XI0_I970_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I970_MP6 (XI0_I970_p1 I0_A_27_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I970_MP8 (XI0_I970_xn I0_A_26_b3_3 XI0_I970_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I970_MP7 (XI0_I970_p1 I0_two8_b3_4 XI0_I970_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I970_MP5 (VDD I0_one8_b3_4 XI0_I970_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I970_MP10 (XI0_I970_xan XI0_I970_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I969_MP12 (VDD I0_B_17_b3_4 XI0_I969_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I969_MP18 (XI0_I969_xp1 XI0_I969_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I969_MP20 (I0_pp8_26 I0_B_17_b3_4 XI0_I969_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I969_MP19 (XI0_I969_xp1 XI0_I969_xan I0_pp8_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I969_MP17 (VDD XI0_I969_xn XI0_I969_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I969_MP6 (XI0_I969_p1 I0_A_26_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I969_MP8 (XI0_I969_xn I0_A_25_b3_3 XI0_I969_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I969_MP7 (XI0_I969_p1 I0_two8_b3_4 XI0_I969_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I969_MP5 (VDD I0_one8_b3_4 XI0_I969_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I969_MP10 (XI0_I969_xan XI0_I969_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1181_MP12 (VDD I0_B_25_b3_3 XI0_I1181_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1181_MP18 (XI0_I1181_xp1 XI0_I1181_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1181_MP20 (I0_pp12_18 I0_B_25_b3_3 XI0_I1181_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1181_MP19 (XI0_I1181_xp1 XI0_I1181_xan I0_pp12_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1181_MP17 (VDD XI0_I1181_xn XI0_I1181_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1181_MP6 (XI0_I1181_p1 I0_A_18_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1181_MP8 (XI0_I1181_xn I0_A_17_b3_4 XI0_I1181_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1181_MP7 (XI0_I1181_p1 I0_two12_b3_3 XI0_I1181_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1181_MP5 (VDD I0_one12_b3_3 XI0_I1181_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1181_MP10 (XI0_I1181_xan XI0_I1181_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1126_MP12 (VDD I0_B_23_b3_3 XI0_I1126_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1126_MP18 (XI0_I1126_xp1 XI0_I1126_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1126_MP20 (I0_pp11_18 I0_B_23_b3_3 XI0_I1126_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1126_MP19 (XI0_I1126_xp1 XI0_I1126_xan I0_pp11_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1126_MP17 (VDD XI0_I1126_xn XI0_I1126_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1126_MP6 (XI0_I1126_p1 I0_A_18_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1126_MP8 (XI0_I1126_xn I0_A_17_b3_4 XI0_I1126_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1126_MP7 (XI0_I1126_p1 I0_two11_b3_3 XI0_I1126_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1126_MP5 (VDD I0_one11_b3_3 XI0_I1126_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1126_MP10 (XI0_I1126_xan XI0_I1126_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1180_MP12 (VDD I0_B_25_b3_3 XI0_I1180_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1180_MP18 (XI0_I1180_xp1 XI0_I1180_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1180_MP20 (I0_pp12_17 I0_B_25_b3_3 XI0_I1180_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1180_MP19 (XI0_I1180_xp1 XI0_I1180_xan I0_pp12_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1180_MP17 (VDD XI0_I1180_xn XI0_I1180_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1180_MP6 (XI0_I1180_p1 I0_A_17_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1180_MP8 (XI0_I1180_xn I0_A_16_b3_4 XI0_I1180_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1180_MP7 (XI0_I1180_p1 I0_two12_b3_3 XI0_I1180_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1180_MP5 (VDD I0_one12_b3_3 XI0_I1180_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1180_MP10 (XI0_I1180_xan XI0_I1180_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1125_MP12 (VDD I0_B_23_b3_3 XI0_I1125_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1125_MP18 (XI0_I1125_xp1 XI0_I1125_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1125_MP20 (I0_pp11_17 I0_B_23_b3_3 XI0_I1125_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1125_MP19 (XI0_I1125_xp1 XI0_I1125_xan I0_pp11_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1125_MP17 (VDD XI0_I1125_xn XI0_I1125_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1125_MP6 (XI0_I1125_p1 I0_A_17_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1125_MP8 (XI0_I1125_xn I0_A_16_b3_4 XI0_I1125_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1125_MP7 (XI0_I1125_p1 I0_two11_b3_3 XI0_I1125_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1125_MP5 (VDD I0_one11_b3_3 XI0_I1125_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1125_MP10 (XI0_I1125_xan XI0_I1125_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1079_MP12 (VDD I0_B_21_b3_4 XI0_I1079_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1079_MP18 (XI0_I1079_xp1 XI0_I1079_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1079_MP20 (I0_pp10_26 I0_B_21_b3_4 XI0_I1079_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1079_MP19 (XI0_I1079_xp1 XI0_I1079_xan I0_pp10_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1079_MP17 (VDD XI0_I1079_xn XI0_I1079_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1079_MP6 (XI0_I1079_p1 I0_A_26_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1079_MP8 (XI0_I1079_xn I0_A_25_b3_3 XI0_I1079_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1079_MP7 (XI0_I1079_p1 I0_two10_b3_4 XI0_I1079_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1079_MP5 (VDD I0_one10_b3_4 XI0_I1079_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1079_MP10 (XI0_I1079_xan XI0_I1079_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1078_MP12 (VDD I0_B_21_b3_4 XI0_I1078_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1078_MP18 (XI0_I1078_xp1 XI0_I1078_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1078_MP20 (I0_pp10_25 I0_B_21_b3_4 XI0_I1078_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1078_MP19 (XI0_I1078_xp1 XI0_I1078_xan I0_pp10_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1078_MP17 (VDD XI0_I1078_xn XI0_I1078_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1078_MP6 (XI0_I1078_p1 I0_A_25_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1078_MP8 (XI0_I1078_xn I0_A_24_b3_3 XI0_I1078_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1078_MP7 (XI0_I1078_p1 I0_two10_b3_4 XI0_I1078_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1078_MP5 (VDD I0_one10_b3_4 XI0_I1078_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1078_MP10 (XI0_I1078_xan XI0_I1078_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1024_MP12 (VDD I0_B_19_b3_4 XI0_I1024_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1024_MP18 (XI0_I1024_xp1 XI0_I1024_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1024_MP20 (I0_pp9_26 I0_B_19_b3_4 XI0_I1024_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1024_MP19 (XI0_I1024_xp1 XI0_I1024_xan I0_pp9_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1024_MP17 (VDD XI0_I1024_xn XI0_I1024_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1024_MP6 (XI0_I1024_p1 I0_A_26_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1024_MP8 (XI0_I1024_xn I0_A_25_b3_3 XI0_I1024_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1024_MP7 (XI0_I1024_p1 I0_two9_b3_4 XI0_I1024_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1024_MP5 (VDD I0_one9_b3_4 XI0_I1024_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1024_MP10 (XI0_I1024_xan XI0_I1024_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1076_MP12 (VDD I0_B_21_b3_4 XI0_I1076_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1076_MP18 (XI0_I1076_xp1 XI0_I1076_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1076_MP20 (I0_pp10_23 I0_B_21_b3_4 XI0_I1076_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1076_MP19 (XI0_I1076_xp1 XI0_I1076_xan I0_pp10_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1076_MP17 (VDD XI0_I1076_xn XI0_I1076_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1076_MP6 (XI0_I1076_p1 I0_A_23_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1076_MP8 (XI0_I1076_xn I0_A_22_b3_3 XI0_I1076_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1076_MP7 (XI0_I1076_p1 I0_two10_b3_4 XI0_I1076_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1076_MP5 (VDD I0_one10_b3_4 XI0_I1076_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1076_MP10 (XI0_I1076_xan XI0_I1076_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1080_MP12 (VDD I0_B_21_b3_4 XI0_I1080_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1080_MP18 (XI0_I1080_xp1 XI0_I1080_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1080_MP20 (I0_pp10_27 I0_B_21_b3_4 XI0_I1080_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1080_MP19 (XI0_I1080_xp1 XI0_I1080_xan I0_pp10_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1080_MP17 (VDD XI0_I1080_xn XI0_I1080_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1080_MP6 (XI0_I1080_p1 I0_A_27_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1080_MP8 (XI0_I1080_xn I0_A_26_b3_3 XI0_I1080_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1080_MP7 (XI0_I1080_p1 I0_two10_b3_4 XI0_I1080_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1080_MP5 (VDD I0_one10_b3_4 XI0_I1080_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1080_MP10 (XI0_I1080_xan XI0_I1080_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1025_MP12 (VDD I0_B_19_b3_4 XI0_I1025_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1025_MP18 (XI0_I1025_xp1 XI0_I1025_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1025_MP20 (I0_pp9_27 I0_B_19_b3_4 XI0_I1025_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1025_MP19 (XI0_I1025_xp1 XI0_I1025_xan I0_pp9_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1025_MP17 (VDD XI0_I1025_xn XI0_I1025_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1025_MP6 (XI0_I1025_p1 I0_A_27_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1025_MP8 (XI0_I1025_xn I0_A_26_b3_3 XI0_I1025_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1025_MP7 (XI0_I1025_p1 I0_two9_b3_4 XI0_I1025_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1025_MP5 (VDD I0_one9_b3_4 XI0_I1025_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1025_MP10 (XI0_I1025_xan XI0_I1025_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1023_MP12 (VDD I0_B_19_b3_4 XI0_I1023_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1023_MP18 (XI0_I1023_xp1 XI0_I1023_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1023_MP20 (I0_pp9_25 I0_B_19_b3_4 XI0_I1023_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1023_MP19 (XI0_I1023_xp1 XI0_I1023_xan I0_pp9_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1023_MP17 (VDD XI0_I1023_xn XI0_I1023_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1023_MP6 (XI0_I1023_p1 I0_A_25_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1023_MP8 (XI0_I1023_xn I0_A_24_b3_3 XI0_I1023_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1023_MP7 (XI0_I1023_p1 I0_two9_b3_4 XI0_I1023_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1023_MP5 (VDD I0_one9_b3_4 XI0_I1023_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1023_MP10 (XI0_I1023_xan XI0_I1023_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1236_MP12 (VDD I0_B_27_b3_3 XI0_I1236_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1236_MP18 (XI0_I1236_xp1 XI0_I1236_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1236_MP20 (I0_pp13_18 I0_B_27_b3_3 XI0_I1236_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1236_MP19 (XI0_I1236_xp1 XI0_I1236_xan I0_pp13_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1236_MP17 (VDD XI0_I1236_xn XI0_I1236_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1236_MP6 (XI0_I1236_p1 I0_A_18_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1236_MP8 (XI0_I1236_xn I0_A_17_b3_5 XI0_I1236_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1236_MP7 (XI0_I1236_p1 I0_two13_b3_3 XI0_I1236_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1236_MP5 (VDD I0_one13_b3_3 XI0_I1236_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1236_MP10 (XI0_I1236_xan XI0_I1236_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1235_MP12 (VDD I0_B_27_b3_3 XI0_I1235_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1235_MP18 (XI0_I1235_xp1 XI0_I1235_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1235_MP20 (I0_pp13_17 I0_B_27_b3_3 XI0_I1235_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1235_MP19 (XI0_I1235_xp1 XI0_I1235_xan I0_pp13_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1235_MP17 (VDD XI0_I1235_xn XI0_I1235_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1235_MP6 (XI0_I1235_p1 I0_A_17_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1235_MP8 (XI0_I1235_xn I0_A_16_b3_5 XI0_I1235_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1235_MP7 (XI0_I1235_p1 I0_two13_b3_3 XI0_I1235_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1235_MP5 (VDD I0_one13_b3_3 XI0_I1235_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1235_MP10 (XI0_I1235_xan XI0_I1235_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1183_MP12 (VDD I0_B_25_b3_3 XI0_I1183_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1183_MP18 (XI0_I1183_xp1 XI0_I1183_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1183_MP20 (I0_pp12_20 I0_B_25_b3_3 XI0_I1183_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1183_MP19 (XI0_I1183_xp1 XI0_I1183_xan I0_pp12_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1183_MP17 (VDD XI0_I1183_xn XI0_I1183_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1183_MP6 (XI0_I1183_p1 I0_A_20_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1183_MP8 (XI0_I1183_xn I0_A_19_b3_4 XI0_I1183_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1183_MP7 (XI0_I1183_p1 I0_two12_b3_3 XI0_I1183_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1183_MP5 (VDD I0_one12_b3_3 XI0_I1183_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1183_MP10 (XI0_I1183_xan XI0_I1183_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1182_MP12 (VDD I0_B_25_b3_3 XI0_I1182_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1182_MP18 (XI0_I1182_xp1 XI0_I1182_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1182_MP20 (I0_pp12_19 I0_B_25_b3_3 XI0_I1182_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1182_MP19 (XI0_I1182_xp1 XI0_I1182_xan I0_pp12_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1182_MP17 (VDD XI0_I1182_xn XI0_I1182_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1182_MP6 (XI0_I1182_p1 I0_A_19_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1182_MP8 (XI0_I1182_xn I0_A_18_b3_4 XI0_I1182_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1182_MP7 (XI0_I1182_p1 I0_two12_b3_3 XI0_I1182_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1182_MP5 (VDD I0_one12_b3_3 XI0_I1182_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1182_MP10 (XI0_I1182_xan XI0_I1182_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1128_MP12 (VDD I0_B_23_b3_3 XI0_I1128_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1128_MP18 (XI0_I1128_xp1 XI0_I1128_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1128_MP20 (I0_pp11_20 I0_B_23_b3_3 XI0_I1128_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1128_MP19 (XI0_I1128_xp1 XI0_I1128_xan I0_pp11_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1128_MP17 (VDD XI0_I1128_xn XI0_I1128_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1128_MP6 (XI0_I1128_p1 I0_A_20_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1128_MP8 (XI0_I1128_xn I0_A_19_b3_4 XI0_I1128_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1128_MP7 (XI0_I1128_p1 I0_two11_b3_3 XI0_I1128_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1128_MP5 (VDD I0_one11_b3_3 XI0_I1128_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1128_MP10 (XI0_I1128_xan XI0_I1128_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1127_MP12 (VDD I0_B_23_b3_3 XI0_I1127_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1127_MP18 (XI0_I1127_xp1 XI0_I1127_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1127_MP20 (I0_pp11_19 I0_B_23_b3_3 XI0_I1127_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1127_MP19 (XI0_I1127_xp1 XI0_I1127_xan I0_pp11_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1127_MP17 (VDD XI0_I1127_xn XI0_I1127_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1127_MP6 (XI0_I1127_p1 I0_A_19_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1127_MP8 (XI0_I1127_xn I0_A_18_b3_4 XI0_I1127_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1127_MP7 (XI0_I1127_p1 I0_two11_b3_3 XI0_I1127_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1127_MP5 (VDD I0_one11_b3_3 XI0_I1127_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1127_MP10 (XI0_I1127_xan XI0_I1127_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1193_MP12 (VDD I0_B_25_b3_5 XI0_I1193_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1193_MP18 (XI0_I1193_xp1 XI0_I1193_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1193_MP20 (I0_pp12_30 I0_B_25_b3_5 XI0_I1193_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1193_MP19 (XI0_I1193_xp1 XI0_I1193_xan I0_pp12_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1193_MP17 (VDD XI0_I1193_xn XI0_I1193_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1193_MP6 (XI0_I1193_p1 I0_A_30_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1193_MP8 (XI0_I1193_xn I0_A_29_b3_4 XI0_I1193_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1193_MP7 (XI0_I1193_p1 I0_two12_b3_5 XI0_I1193_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1193_MP5 (VDD I0_one12_b3_5 XI0_I1193_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1193_MP10 (XI0_I1193_xan XI0_I1193_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1237_MP12 (VDD I0_B_27_b3_3 XI0_I1237_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1237_MP18 (XI0_I1237_xp1 XI0_I1237_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1237_MP20 (I0_pp13_19 I0_B_27_b3_3 XI0_I1237_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1237_MP19 (XI0_I1237_xp1 XI0_I1237_xan I0_pp13_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1237_MP17 (VDD XI0_I1237_xn XI0_I1237_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1237_MP6 (XI0_I1237_p1 I0_A_19_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1237_MP8 (XI0_I1237_xn I0_A_18_b3_5 XI0_I1237_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1237_MP7 (XI0_I1237_p1 I0_two13_b3_3 XI0_I1237_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1237_MP5 (VDD I0_one13_b3_3 XI0_I1237_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1237_MP10 (XI0_I1237_xan XI0_I1237_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1184_MP12 (VDD I0_B_25_b3_3 XI0_I1184_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1184_MP18 (XI0_I1184_xp1 XI0_I1184_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1184_MP20 (I0_pp12_21 I0_B_25_b3_3 XI0_I1184_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1184_MP19 (XI0_I1184_xp1 XI0_I1184_xan I0_pp12_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1184_MP17 (VDD XI0_I1184_xn XI0_I1184_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1184_MP6 (XI0_I1184_p1 I0_A_21_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1184_MP8 (XI0_I1184_xn I0_A_20_b3_4 XI0_I1184_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1184_MP7 (XI0_I1184_p1 I0_two12_b3_3 XI0_I1184_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1184_MP5 (VDD I0_one12_b3_3 XI0_I1184_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1184_MP10 (XI0_I1184_xan XI0_I1184_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1129_MP12 (VDD I0_B_23_b3_3 XI0_I1129_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1129_MP18 (XI0_I1129_xp1 XI0_I1129_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1129_MP20 (I0_pp11_21 I0_B_23_b3_3 XI0_I1129_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1129_MP19 (XI0_I1129_xp1 XI0_I1129_xan I0_pp11_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1129_MP17 (VDD XI0_I1129_xn XI0_I1129_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1129_MP6 (XI0_I1129_p1 I0_A_21_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1129_MP8 (XI0_I1129_xn I0_A_20_b3_4 XI0_I1129_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1129_MP7 (XI0_I1129_p1 I0_two11_b3_3 XI0_I1129_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1129_MP5 (VDD I0_one11_b3_3 XI0_I1129_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1129_MP10 (XI0_I1129_xan XI0_I1129_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1195_MP12 (VDD I0_B_25_b3_5 XI0_I1195_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1195_MP18 (XI0_I1195_xp1 XI0_I1195_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1195_MP20 (I0_pp12_32 I0_B_25_b3_5 XI0_I1195_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1195_MP19 (XI0_I1195_xp1 XI0_I1195_xan I0_pp12_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1195_MP17 (VDD XI0_I1195_xn XI0_I1195_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1195_MP6 (XI0_I1195_p1 I0_A_31_b3_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1195_MP8 (XI0_I1195_xn I0_A_31_b3_6 XI0_I1195_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1195_MP7 (XI0_I1195_p1 I0_two12_b3_5 XI0_I1195_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1195_MP5 (VDD I0_one12_b3_5 XI0_I1195_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1195_MP10 (XI0_I1195_xan XI0_I1195_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1250_MP12 (VDD I0_B_27_b3_5 XI0_I1250_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1250_MP18 (XI0_I1250_xp1 XI0_I1250_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1250_MP20 (I0_pp13_32 I0_B_27_b3_5 XI0_I1250_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1250_MP19 (XI0_I1250_xp1 XI0_I1250_xan I0_pp13_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1250_MP17 (VDD XI0_I1250_xn XI0_I1250_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1250_MP6 (XI0_I1250_p1 I0_A_31_b3_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1250_MP8 (XI0_I1250_xn I0_A_31_b3_6 XI0_I1250_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1250_MP7 (XI0_I1250_p1 I0_two13_b3_5 XI0_I1250_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1250_MP5 (VDD I0_one13_b3_5 XI0_I1250_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1250_MP10 (XI0_I1250_xan XI0_I1250_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1194_MP12 (VDD I0_B_25_b3_5 XI0_I1194_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1194_MP18 (XI0_I1194_xp1 XI0_I1194_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1194_MP20 (I0_pp12_31 I0_B_25_b3_5 XI0_I1194_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1194_MP19 (XI0_I1194_xp1 XI0_I1194_xan I0_pp12_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1194_MP17 (VDD XI0_I1194_xn XI0_I1194_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1194_MP6 (XI0_I1194_p1 I0_A_31_b3_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1194_MP8 (XI0_I1194_xn I0_A_30_b3_4 XI0_I1194_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1194_MP7 (XI0_I1194_p1 I0_two12_b3_5 XI0_I1194_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1194_MP5 (VDD I0_one12_b3_5 XI0_I1194_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1194_MP10 (XI0_I1194_xan XI0_I1194_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1247_MP12 (VDD I0_B_27_b3_5 XI0_I1247_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1247_MP18 (XI0_I1247_xp1 XI0_I1247_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1247_MP20 (I0_pp13_29 I0_B_27_b3_5 XI0_I1247_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1247_MP19 (XI0_I1247_xp1 XI0_I1247_xan I0_pp13_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1247_MP17 (VDD XI0_I1247_xn XI0_I1247_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1247_MP6 (XI0_I1247_p1 I0_A_29_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1247_MP8 (XI0_I1247_xn I0_A_28_b3_5 XI0_I1247_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1247_MP7 (XI0_I1247_p1 I0_two13_b3_5 XI0_I1247_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1247_MP5 (VDD I0_one13_b3_5 XI0_I1247_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1247_MP10 (XI0_I1247_xan XI0_I1247_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1192_MP12 (VDD I0_B_25_b3_5 XI0_I1192_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1192_MP18 (XI0_I1192_xp1 XI0_I1192_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1192_MP20 (I0_pp12_29 I0_B_25_b3_5 XI0_I1192_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1192_MP19 (XI0_I1192_xp1 XI0_I1192_xan I0_pp12_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1192_MP17 (VDD XI0_I1192_xn XI0_I1192_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1192_MP6 (XI0_I1192_p1 I0_A_29_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1192_MP8 (XI0_I1192_xn I0_A_28_b3_4 XI0_I1192_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1192_MP7 (XI0_I1192_p1 I0_two12_b3_5 XI0_I1192_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1192_MP5 (VDD I0_one12_b3_5 XI0_I1192_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1192_MP10 (XI0_I1192_xan XI0_I1192_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1137_MP12 (VDD I0_B_23_b3_5 XI0_I1137_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1137_MP18 (XI0_I1137_xp1 XI0_I1137_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1137_MP20 (I0_pp11_29 I0_B_23_b3_5 XI0_I1137_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1137_MP19 (XI0_I1137_xp1 XI0_I1137_xan I0_pp11_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1137_MP17 (VDD XI0_I1137_xn XI0_I1137_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1137_MP6 (XI0_I1137_p1 I0_A_29_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1137_MP8 (XI0_I1137_xn I0_A_28_b3_4 XI0_I1137_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1137_MP7 (XI0_I1137_p1 I0_two11_b3_5 XI0_I1137_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1137_MP5 (VDD I0_one11_b3_5 XI0_I1137_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1137_MP10 (XI0_I1137_xan XI0_I1137_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1191_MP12 (VDD I0_B_25_b3_4 XI0_I1191_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1191_MP18 (XI0_I1191_xp1 XI0_I1191_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1191_MP20 (I0_pp12_28 I0_B_25_b3_4 XI0_I1191_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1191_MP19 (XI0_I1191_xp1 XI0_I1191_xan I0_pp12_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1191_MP17 (VDD XI0_I1191_xn XI0_I1191_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1191_MP6 (XI0_I1191_p1 I0_A_28_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1191_MP8 (XI0_I1191_xn I0_A_27_b3_4 XI0_I1191_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1191_MP7 (XI0_I1191_p1 I0_two12_b3_5 XI0_I1191_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1191_MP5 (VDD I0_one12_b3_5 XI0_I1191_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1191_MP10 (XI0_I1191_xan XI0_I1191_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1136_MP12 (VDD I0_B_23_b3_4 XI0_I1136_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1136_MP18 (XI0_I1136_xp1 XI0_I1136_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1136_MP20 (I0_pp11_28 I0_B_23_b3_4 XI0_I1136_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1136_MP19 (XI0_I1136_xp1 XI0_I1136_xan I0_pp11_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1136_MP17 (VDD XI0_I1136_xn XI0_I1136_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1136_MP6 (XI0_I1136_p1 I0_A_28_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1136_MP8 (XI0_I1136_xn I0_A_27_b3_4 XI0_I1136_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1136_MP7 (XI0_I1136_p1 I0_two11_b3_5 XI0_I1136_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1136_MP5 (VDD I0_one11_b3_5 XI0_I1136_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1136_MP10 (XI0_I1136_xan XI0_I1136_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1239_MP12 (VDD I0_B_27_b3_3 XI0_I1239_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1239_MP18 (XI0_I1239_xp1 XI0_I1239_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1239_MP20 (I0_pp13_21 I0_B_27_b3_3 XI0_I1239_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1239_MP19 (XI0_I1239_xp1 XI0_I1239_xan I0_pp13_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1239_MP17 (VDD XI0_I1239_xn XI0_I1239_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1239_MP6 (XI0_I1239_p1 I0_A_21_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1239_MP8 (XI0_I1239_xn I0_A_20_b3_5 XI0_I1239_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1239_MP7 (XI0_I1239_p1 I0_two13_b3_3 XI0_I1239_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1239_MP5 (VDD I0_one13_b3_3 XI0_I1239_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1239_MP10 (XI0_I1239_xan XI0_I1239_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1238_MP12 (VDD I0_B_27_b3_3 XI0_I1238_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1238_MP18 (XI0_I1238_xp1 XI0_I1238_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1238_MP20 (I0_pp13_20 I0_B_27_b3_3 XI0_I1238_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1238_MP19 (XI0_I1238_xp1 XI0_I1238_xan I0_pp13_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1238_MP17 (VDD XI0_I1238_xn XI0_I1238_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1238_MP6 (XI0_I1238_p1 I0_A_20_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1238_MP8 (XI0_I1238_xn I0_A_19_b3_5 XI0_I1238_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1238_MP7 (XI0_I1238_p1 I0_two13_b3_3 XI0_I1238_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1238_MP5 (VDD I0_one13_b3_3 XI0_I1238_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1238_MP10 (XI0_I1238_xan XI0_I1238_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I971_MP12 (VDD I0_B_17_b3_4 XI0_I971_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I971_MP18 (XI0_I971_xp1 XI0_I971_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I971_MP20 (I0_pp8_28 I0_B_17_b3_4 XI0_I971_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I971_MP19 (XI0_I971_xp1 XI0_I971_xan I0_pp8_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I971_MP17 (VDD XI0_I971_xn XI0_I971_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I971_MP6 (XI0_I971_p1 I0_A_28_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I971_MP8 (XI0_I971_xn I0_A_27_b3_3 XI0_I971_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I971_MP7 (XI0_I971_p1 I0_two8_b3_5 XI0_I971_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I971_MP5 (VDD I0_one8_b3_5 XI0_I971_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I971_MP10 (XI0_I971_xan XI0_I971_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1248_MP12 (VDD I0_B_27_b3_5 XI0_I1248_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1248_MP18 (XI0_I1248_xp1 XI0_I1248_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1248_MP20 (I0_pp13_30 I0_B_27_b3_5 XI0_I1248_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1248_MP19 (XI0_I1248_xp1 XI0_I1248_xan I0_pp13_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1248_MP17 (VDD XI0_I1248_xn XI0_I1248_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1248_MP6 (XI0_I1248_p1 I0_A_30_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1248_MP8 (XI0_I1248_xn I0_A_29_b3_5 XI0_I1248_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1248_MP7 (XI0_I1248_p1 I0_two13_b3_5 XI0_I1248_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1248_MP5 (VDD I0_one13_b3_5 XI0_I1248_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1248_MP10 (XI0_I1248_xan XI0_I1248_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1249_MP12 (VDD I0_B_27_b3_5 XI0_I1249_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1249_MP18 (XI0_I1249_xp1 XI0_I1249_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1249_MP20 (I0_pp13_31 I0_B_27_b3_5 XI0_I1249_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1249_MP19 (XI0_I1249_xp1 XI0_I1249_xan I0_pp13_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1249_MP17 (VDD XI0_I1249_xn XI0_I1249_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1249_MP6 (XI0_I1249_p1 I0_A_31_b3_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1249_MP8 (XI0_I1249_xn I0_A_30_b3_5 XI0_I1249_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1249_MP7 (XI0_I1249_p1 I0_two13_b3_5 XI0_I1249_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1249_MP5 (VDD I0_one13_b3_5 XI0_I1249_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1249_MP10 (XI0_I1249_xan XI0_I1249_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1138_MP12 (VDD I0_B_23_b3_5 XI0_I1138_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1138_MP18 (XI0_I1138_xp1 XI0_I1138_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1138_MP20 (I0_pp11_30 I0_B_23_b3_5 XI0_I1138_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1138_MP19 (XI0_I1138_xp1 XI0_I1138_xan I0_pp11_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1138_MP17 (VDD XI0_I1138_xn XI0_I1138_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1138_MP6 (XI0_I1138_p1 I0_A_30_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1138_MP8 (XI0_I1138_xn I0_A_29_b3_4 XI0_I1138_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1138_MP7 (XI0_I1138_p1 I0_two11_b3_5 XI0_I1138_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1138_MP5 (VDD I0_one11_b3_5 XI0_I1138_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1138_MP10 (XI0_I1138_xan XI0_I1138_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1246_MP12 (VDD I0_B_27_b3_4 XI0_I1246_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1246_MP18 (XI0_I1246_xp1 XI0_I1246_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1246_MP20 (I0_pp13_28 I0_B_27_b3_4 XI0_I1246_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1246_MP19 (XI0_I1246_xp1 XI0_I1246_xan I0_pp13_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1246_MP17 (VDD XI0_I1246_xn XI0_I1246_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1246_MP6 (XI0_I1246_p1 I0_A_28_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1246_MP8 (XI0_I1246_xn I0_A_27_b3_5 XI0_I1246_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1246_MP7 (XI0_I1246_p1 I0_two13_b3_5 XI0_I1246_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1246_MP5 (VDD I0_one13_b3_5 XI0_I1246_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1246_MP10 (XI0_I1246_xan XI0_I1246_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1139_MP12 (VDD I0_B_23_b3_5 XI0_I1139_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1139_MP18 (XI0_I1139_xp1 XI0_I1139_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1139_MP20 (I0_pp11_31 I0_B_23_b3_5 XI0_I1139_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1139_MP19 (XI0_I1139_xp1 XI0_I1139_xan I0_pp11_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1139_MP17 (VDD XI0_I1139_xn XI0_I1139_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1139_MP6 (XI0_I1139_p1 I0_A_31_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1139_MP8 (XI0_I1139_xn I0_A_30_b3_4 XI0_I1139_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1139_MP7 (XI0_I1139_p1 I0_two11_b3_5 XI0_I1139_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1139_MP5 (VDD I0_one11_b3_5 XI0_I1139_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1139_MP10 (XI0_I1139_xan XI0_I1139_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1185_MP12 (VDD I0_B_25_b3_3 XI0_I1185_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1185_MP18 (XI0_I1185_xp1 XI0_I1185_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1185_MP20 (I0_pp12_22 I0_B_25_b3_3 XI0_I1185_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1185_MP19 (XI0_I1185_xp1 XI0_I1185_xan I0_pp12_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1185_MP17 (VDD XI0_I1185_xn XI0_I1185_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1185_MP6 (XI0_I1185_p1 I0_A_22_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1185_MP8 (XI0_I1185_xn I0_A_21_b3_4 XI0_I1185_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1185_MP7 (XI0_I1185_p1 I0_two12_b3_4 XI0_I1185_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1185_MP5 (VDD I0_one12_b3_4 XI0_I1185_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1185_MP10 (XI0_I1185_xan XI0_I1185_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1240_MP12 (VDD I0_B_27_b3_3 XI0_I1240_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1240_MP18 (XI0_I1240_xp1 XI0_I1240_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1240_MP20 (I0_pp13_22 I0_B_27_b3_3 XI0_I1240_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1240_MP19 (XI0_I1240_xp1 XI0_I1240_xan I0_pp13_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1240_MP17 (VDD XI0_I1240_xn XI0_I1240_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1240_MP6 (XI0_I1240_p1 I0_A_22_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1240_MP8 (XI0_I1240_xn I0_A_21_b3_5 XI0_I1240_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1240_MP7 (XI0_I1240_p1 I0_two13_b3_4 XI0_I1240_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1240_MP5 (VDD I0_one13_b3_4 XI0_I1240_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1240_MP10 (XI0_I1240_xan XI0_I1240_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1130_MP12 (VDD I0_B_23_b3_3 XI0_I1130_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1130_MP18 (XI0_I1130_xp1 XI0_I1130_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1130_MP20 (I0_pp11_22 I0_B_23_b3_3 XI0_I1130_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1130_MP19 (XI0_I1130_xp1 XI0_I1130_xan I0_pp11_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1130_MP17 (VDD XI0_I1130_xn XI0_I1130_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1130_MP6 (XI0_I1130_p1 I0_A_22_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1130_MP8 (XI0_I1130_xn I0_A_21_b3_4 XI0_I1130_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1130_MP7 (XI0_I1130_p1 I0_two11_b3_4 XI0_I1130_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1130_MP5 (VDD I0_one11_b3_4 XI0_I1130_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1130_MP10 (XI0_I1130_xan XI0_I1130_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1081_MP12 (VDD I0_B_21_b3_4 XI0_I1081_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1081_MP18 (XI0_I1081_xp1 XI0_I1081_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1081_MP20 (I0_pp10_28 I0_B_21_b3_4 XI0_I1081_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1081_MP19 (XI0_I1081_xp1 XI0_I1081_xan I0_pp10_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1081_MP17 (VDD XI0_I1081_xn XI0_I1081_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1081_MP6 (XI0_I1081_p1 I0_A_28_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1081_MP8 (XI0_I1081_xn I0_A_27_b3_3 XI0_I1081_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1081_MP7 (XI0_I1081_p1 I0_two10_b3_5 XI0_I1081_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1081_MP5 (VDD I0_one10_b3_5 XI0_I1081_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1081_MP10 (XI0_I1081_xan XI0_I1081_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I972_MP12 (VDD I0_B_17_b3_5 XI0_I972_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I972_MP18 (XI0_I972_xp1 XI0_I972_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I972_MP20 (I0_pp8_29 I0_B_17_b3_5 XI0_I972_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I972_MP19 (XI0_I972_xp1 XI0_I972_xan I0_pp8_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I972_MP17 (VDD XI0_I972_xn XI0_I972_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I972_MP6 (XI0_I972_p1 I0_A_29_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I972_MP8 (XI0_I972_xn I0_A_28_b3_3 XI0_I972_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I972_MP7 (XI0_I972_p1 I0_two8_b3_5 XI0_I972_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I972_MP5 (VDD I0_one8_b3_5 XI0_I972_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I972_MP10 (XI0_I972_xan XI0_I972_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1026_MP12 (VDD I0_B_19_b3_4 XI0_I1026_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1026_MP18 (XI0_I1026_xp1 XI0_I1026_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1026_MP20 (I0_pp9_28 I0_B_19_b3_4 XI0_I1026_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1026_MP19 (XI0_I1026_xp1 XI0_I1026_xan I0_pp9_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1026_MP17 (VDD XI0_I1026_xn XI0_I1026_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1026_MP6 (XI0_I1026_p1 I0_A_28_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1026_MP8 (XI0_I1026_xn I0_A_27_b3_3 XI0_I1026_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1026_MP7 (XI0_I1026_p1 I0_two9_b3_5 XI0_I1026_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1026_MP5 (VDD I0_one9_b3_5 XI0_I1026_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1026_MP10 (XI0_I1026_xan XI0_I1026_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1140_MP12 (VDD I0_B_23_b3_5 XI0_I1140_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1140_MP18 (XI0_I1140_xp1 XI0_I1140_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1140_MP20 (I0_pp11_32 I0_B_23_b3_5 XI0_I1140_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1140_MP19 (XI0_I1140_xp1 XI0_I1140_xan I0_pp11_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1140_MP17 (VDD XI0_I1140_xn XI0_I1140_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1140_MP6 (XI0_I1140_p1 I0_A_31_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1140_MP8 (XI0_I1140_xn I0_A_31_b3_5 XI0_I1140_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1140_MP7 (XI0_I1140_p1 I0_two11_b3_5 XI0_I1140_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1140_MP5 (VDD I0_one11_b3_5 XI0_I1140_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1140_MP10 (XI0_I1140_xan XI0_I1140_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1290_MP12 (VDD I0_B_29_b3_3 XI0_I1290_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1290_MP18 (XI0_I1290_xp1 XI0_I1290_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1290_MP20 (I0_pp14_17 I0_B_29_b3_3 XI0_I1290_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1290_MP19 (XI0_I1290_xp1 XI0_I1290_xan I0_pp14_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1290_MP17 (VDD XI0_I1290_xn XI0_I1290_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1290_MP6 (XI0_I1290_p1 I0_A_17_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1290_MP8 (XI0_I1290_xn I0_A_16_b3_5 XI0_I1290_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1290_MP7 (XI0_I1290_p1 I0_two14_b3_3 XI0_I1290_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1290_MP5 (VDD I0_one14_b3_3 XI0_I1290_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1290_MP10 (XI0_I1290_xan XI0_I1290_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1291_MP12 (VDD I0_B_29_b3_3 XI0_I1291_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1291_MP18 (XI0_I1291_xp1 XI0_I1291_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1291_MP20 (I0_pp14_18 I0_B_29_b3_3 XI0_I1291_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1291_MP19 (XI0_I1291_xp1 XI0_I1291_xan I0_pp14_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1291_MP17 (VDD XI0_I1291_xn XI0_I1291_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1291_MP6 (XI0_I1291_p1 I0_A_18_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1291_MP8 (XI0_I1291_xn I0_A_17_b3_5 XI0_I1291_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1291_MP7 (XI0_I1291_p1 I0_two14_b3_3 XI0_I1291_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1291_MP5 (VDD I0_one14_b3_3 XI0_I1291_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1291_MP10 (XI0_I1291_xan XI0_I1291_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1186_MP12 (VDD I0_B_25_b3_4 XI0_I1186_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1186_MP18 (XI0_I1186_xp1 XI0_I1186_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1186_MP20 (I0_pp12_23 I0_B_25_b3_4 XI0_I1186_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1186_MP19 (XI0_I1186_xp1 XI0_I1186_xan I0_pp12_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1186_MP17 (VDD XI0_I1186_xn XI0_I1186_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1186_MP6 (XI0_I1186_p1 I0_A_23_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1186_MP8 (XI0_I1186_xn I0_A_22_b3_4 XI0_I1186_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1186_MP7 (XI0_I1186_p1 I0_two12_b3_4 XI0_I1186_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1186_MP5 (VDD I0_one12_b3_4 XI0_I1186_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1186_MP10 (XI0_I1186_xan XI0_I1186_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1293_MP12 (VDD I0_B_29_b3_3 XI0_I1293_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1293_MP18 (XI0_I1293_xp1 XI0_I1293_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1293_MP20 (I0_pp14_20 I0_B_29_b3_3 XI0_I1293_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1293_MP19 (XI0_I1293_xp1 XI0_I1293_xan I0_pp14_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1293_MP17 (VDD XI0_I1293_xn XI0_I1293_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1293_MP6 (XI0_I1293_p1 I0_A_20_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1293_MP8 (XI0_I1293_xn I0_A_19_b3_5 XI0_I1293_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1293_MP7 (XI0_I1293_p1 I0_two14_b3_3 XI0_I1293_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1293_MP5 (VDD I0_one14_b3_3 XI0_I1293_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1293_MP10 (XI0_I1293_xan XI0_I1293_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1292_MP12 (VDD I0_B_29_b3_3 XI0_I1292_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1292_MP18 (XI0_I1292_xp1 XI0_I1292_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1292_MP20 (I0_pp14_19 I0_B_29_b3_3 XI0_I1292_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1292_MP19 (XI0_I1292_xp1 XI0_I1292_xan I0_pp14_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1292_MP17 (VDD XI0_I1292_xn XI0_I1292_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1292_MP6 (XI0_I1292_p1 I0_A_19_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1292_MP8 (XI0_I1292_xn I0_A_18_b3_5 XI0_I1292_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1292_MP7 (XI0_I1292_p1 I0_two14_b3_3 XI0_I1292_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1292_MP5 (VDD I0_one14_b3_3 XI0_I1292_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1292_MP10 (XI0_I1292_xan XI0_I1292_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1132_MP12 (VDD I0_B_23_b3_4 XI0_I1132_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1132_MP18 (XI0_I1132_xp1 XI0_I1132_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1132_MP20 (I0_pp11_24 I0_B_23_b3_4 XI0_I1132_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1132_MP19 (XI0_I1132_xp1 XI0_I1132_xan I0_pp11_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1132_MP17 (VDD XI0_I1132_xn XI0_I1132_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1132_MP6 (XI0_I1132_p1 I0_A_24_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1132_MP8 (XI0_I1132_xn I0_A_23_b3_4 XI0_I1132_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1132_MP7 (XI0_I1132_p1 I0_two11_b3_4 XI0_I1132_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1132_MP5 (VDD I0_one11_b3_4 XI0_I1132_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1132_MP10 (XI0_I1132_xan XI0_I1132_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1085_MP12 (VDD I0_B_21_b3_5 XI0_I1085_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1085_MP18 (XI0_I1085_xp1 XI0_I1085_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1085_MP20 (I0_pp10_32 I0_B_21_b3_5 XI0_I1085_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1085_MP19 (XI0_I1085_xp1 XI0_I1085_xan I0_pp10_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1085_MP17 (VDD XI0_I1085_xn XI0_I1085_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1085_MP6 (XI0_I1085_p1 I0_A_31_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1085_MP8 (XI0_I1085_xn I0_A_31_b3_5 XI0_I1085_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1085_MP7 (XI0_I1085_p1 I0_two10_b3_5 XI0_I1085_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1085_MP5 (VDD I0_one10_b3_5 XI0_I1085_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1085_MP10 (XI0_I1085_xan XI0_I1085_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1131_MP12 (VDD I0_B_23_b3_4 XI0_I1131_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1131_MP18 (XI0_I1131_xp1 XI0_I1131_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1131_MP20 (I0_pp11_23 I0_B_23_b3_4 XI0_I1131_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1131_MP19 (XI0_I1131_xp1 XI0_I1131_xan I0_pp11_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1131_MP17 (VDD XI0_I1131_xn XI0_I1131_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1131_MP6 (XI0_I1131_p1 I0_A_23_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1131_MP8 (XI0_I1131_xn I0_A_22_b3_4 XI0_I1131_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1131_MP7 (XI0_I1131_p1 I0_two11_b3_4 XI0_I1131_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1131_MP5 (VDD I0_one11_b3_4 XI0_I1131_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1131_MP10 (XI0_I1131_xan XI0_I1131_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1084_MP12 (VDD I0_B_21_b3_5 XI0_I1084_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1084_MP18 (XI0_I1084_xp1 XI0_I1084_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1084_MP20 (I0_pp10_31 I0_B_21_b3_5 XI0_I1084_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1084_MP19 (XI0_I1084_xp1 XI0_I1084_xan I0_pp10_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1084_MP17 (VDD XI0_I1084_xn XI0_I1084_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1084_MP6 (XI0_I1084_p1 I0_A_31_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1084_MP8 (XI0_I1084_xn I0_A_30_b3_3 XI0_I1084_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1084_MP7 (XI0_I1084_p1 I0_two10_b3_5 XI0_I1084_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1084_MP5 (VDD I0_one10_b3_5 XI0_I1084_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1084_MP10 (XI0_I1084_xan XI0_I1084_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1083_MP12 (VDD I0_B_21_b3_5 XI0_I1083_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1083_MP18 (XI0_I1083_xp1 XI0_I1083_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1083_MP20 (I0_pp10_30 I0_B_21_b3_5 XI0_I1083_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1083_MP19 (XI0_I1083_xp1 XI0_I1083_xan I0_pp10_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1083_MP17 (VDD XI0_I1083_xn XI0_I1083_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1083_MP6 (XI0_I1083_p1 I0_A_30_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1083_MP8 (XI0_I1083_xn I0_A_29_b3_3 XI0_I1083_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1083_MP7 (XI0_I1083_p1 I0_two10_b3_5 XI0_I1083_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1083_MP5 (VDD I0_one10_b3_5 XI0_I1083_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1083_MP10 (XI0_I1083_xan XI0_I1083_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I973_MP12 (VDD I0_B_17_b3_5 XI0_I973_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I973_MP18 (XI0_I973_xp1 XI0_I973_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I973_MP20 (I0_pp8_30 I0_B_17_b3_5 XI0_I973_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I973_MP19 (XI0_I973_xp1 XI0_I973_xan I0_pp8_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I973_MP17 (VDD XI0_I973_xn XI0_I973_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I973_MP6 (XI0_I973_p1 I0_A_30_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I973_MP8 (XI0_I973_xn I0_A_29_b3_3 XI0_I973_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I973_MP7 (XI0_I973_p1 I0_two8_b3_5 XI0_I973_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I973_MP5 (VDD I0_one8_b3_5 XI0_I973_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I973_MP10 (XI0_I973_xan XI0_I973_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1302_MP12 (VDD I0_B_29_b3_5 XI0_I1302_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1302_MP18 (XI0_I1302_xp1 XI0_I1302_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1302_MP20 (I0_pp14_29 I0_B_29_b3_5 XI0_I1302_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1302_MP19 (XI0_I1302_xp1 XI0_I1302_xan I0_pp14_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1302_MP17 (VDD XI0_I1302_xn XI0_I1302_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1302_MP6 (XI0_I1302_p1 I0_A_29_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1302_MP8 (XI0_I1302_xn I0_A_28_b3_5 XI0_I1302_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1302_MP7 (XI0_I1302_p1 I0_two14_b3_5 XI0_I1302_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1302_MP5 (VDD I0_one14_b3_5 XI0_I1302_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1302_MP10 (XI0_I1302_xan XI0_I1302_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1301_MP12 (VDD I0_B_29_b3_4 XI0_I1301_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1301_MP18 (XI0_I1301_xp1 XI0_I1301_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1301_MP20 (I0_pp14_28 I0_B_29_b3_4 XI0_I1301_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1301_MP19 (XI0_I1301_xp1 XI0_I1301_xan I0_pp14_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1301_MP17 (VDD XI0_I1301_xn XI0_I1301_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1301_MP6 (XI0_I1301_p1 I0_A_28_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1301_MP8 (XI0_I1301_xn I0_A_27_b3_5 XI0_I1301_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1301_MP7 (XI0_I1301_p1 I0_two14_b3_5 XI0_I1301_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1301_MP5 (VDD I0_one14_b3_5 XI0_I1301_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1301_MP10 (XI0_I1301_xan XI0_I1301_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1300_MP12 (VDD I0_B_29_b3_4 XI0_I1300_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1300_MP18 (XI0_I1300_xp1 XI0_I1300_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1300_MP20 (I0_pp14_27 I0_B_29_b3_4 XI0_I1300_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1300_MP19 (XI0_I1300_xp1 XI0_I1300_xan I0_pp14_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1300_MP17 (VDD XI0_I1300_xn XI0_I1300_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1300_MP6 (XI0_I1300_p1 I0_A_27_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1300_MP8 (XI0_I1300_xn I0_A_26_b3_5 XI0_I1300_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1300_MP7 (XI0_I1300_p1 I0_two14_b3_4 XI0_I1300_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1300_MP5 (VDD I0_one14_b3_4 XI0_I1300_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1300_MP10 (XI0_I1300_xan XI0_I1300_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1245_MP12 (VDD I0_B_27_b3_4 XI0_I1245_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1245_MP18 (XI0_I1245_xp1 XI0_I1245_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1245_MP20 (I0_pp13_27 I0_B_27_b3_4 XI0_I1245_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1245_MP19 (XI0_I1245_xp1 XI0_I1245_xan I0_pp13_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1245_MP17 (VDD XI0_I1245_xn XI0_I1245_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1245_MP6 (XI0_I1245_p1 I0_A_27_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1245_MP8 (XI0_I1245_xn I0_A_26_b3_5 XI0_I1245_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1245_MP7 (XI0_I1245_p1 I0_two13_b3_4 XI0_I1245_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1245_MP5 (VDD I0_one13_b3_4 XI0_I1245_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1245_MP10 (XI0_I1245_xan XI0_I1245_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1345_MP12 (VDD I0_B_31_b3_3 XI0_I1345_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1345_MP18 (XI0_I1345_xp1 XI0_I1345_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1345_MP20 (I0_pp15_17 I0_B_31_b3_3 XI0_I1345_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1345_MP19 (XI0_I1345_xp1 XI0_I1345_xan I0_pp15_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1345_MP17 (VDD XI0_I1345_xn XI0_I1345_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1345_MP6 (XI0_I1345_p1 I0_A_17_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1345_MP8 (XI0_I1345_xn I0_A_16_b3_5 XI0_I1345_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1345_MP7 (XI0_I1345_p1 I0_two15_b3_3 XI0_I1345_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1345_MP5 (VDD I0_one15_b3_3 XI0_I1345_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1345_MP10 (XI0_I1345_xan XI0_I1345_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1294_MP12 (VDD I0_B_29_b3_3 XI0_I1294_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1294_MP18 (XI0_I1294_xp1 XI0_I1294_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1294_MP20 (I0_pp14_21 I0_B_29_b3_3 XI0_I1294_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1294_MP19 (XI0_I1294_xp1 XI0_I1294_xan I0_pp14_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1294_MP17 (VDD XI0_I1294_xn XI0_I1294_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1294_MP6 (XI0_I1294_p1 I0_A_21_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1294_MP8 (XI0_I1294_xn I0_A_20_b3_5 XI0_I1294_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1294_MP7 (XI0_I1294_p1 I0_two14_b3_3 XI0_I1294_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1294_MP5 (VDD I0_one14_b3_3 XI0_I1294_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1294_MP10 (XI0_I1294_xan XI0_I1294_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1346_MP12 (VDD I0_B_31_b3_3 XI0_I1346_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1346_MP18 (XI0_I1346_xp1 XI0_I1346_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1346_MP20 (I0_pp15_18 I0_B_31_b3_3 XI0_I1346_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1346_MP19 (XI0_I1346_xp1 XI0_I1346_xan I0_pp15_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1346_MP17 (VDD XI0_I1346_xn XI0_I1346_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1346_MP6 (XI0_I1346_p1 I0_A_18_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1346_MP8 (XI0_I1346_xn I0_A_17_b3_5 XI0_I1346_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1346_MP7 (XI0_I1346_p1 I0_two15_b3_3 XI0_I1346_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1346_MP5 (VDD I0_one15_b3_3 XI0_I1346_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1346_MP10 (XI0_I1346_xan XI0_I1346_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1133_MP12 (VDD I0_B_23_b3_4 XI0_I1133_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1133_MP18 (XI0_I1133_xp1 XI0_I1133_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1133_MP20 (I0_pp11_25 I0_B_23_b3_4 XI0_I1133_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1133_MP19 (XI0_I1133_xp1 XI0_I1133_xan I0_pp11_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1133_MP17 (VDD XI0_I1133_xn XI0_I1133_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1133_MP6 (XI0_I1133_p1 I0_A_25_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1133_MP8 (XI0_I1133_xn I0_A_24_b3_4 XI0_I1133_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1133_MP7 (XI0_I1133_p1 I0_two11_b3_4 XI0_I1133_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1133_MP5 (VDD I0_one11_b3_4 XI0_I1133_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1133_MP10 (XI0_I1133_xan XI0_I1133_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1082_MP12 (VDD I0_B_21_b3_5 XI0_I1082_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1082_MP18 (XI0_I1082_xp1 XI0_I1082_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1082_MP20 (I0_pp10_29 I0_B_21_b3_5 XI0_I1082_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1082_MP19 (XI0_I1082_xp1 XI0_I1082_xan I0_pp10_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1082_MP17 (VDD XI0_I1082_xn XI0_I1082_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1082_MP6 (XI0_I1082_p1 I0_A_29_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1082_MP8 (XI0_I1082_xn I0_A_28_b3_3 XI0_I1082_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1082_MP7 (XI0_I1082_p1 I0_two10_b3_5 XI0_I1082_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1082_MP5 (VDD I0_one10_b3_5 XI0_I1082_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1082_MP10 (XI0_I1082_xan XI0_I1082_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1027_MP12 (VDD I0_B_19_b3_5 XI0_I1027_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1027_MP18 (XI0_I1027_xp1 XI0_I1027_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1027_MP20 (I0_pp9_29 I0_B_19_b3_5 XI0_I1027_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1027_MP19 (XI0_I1027_xp1 XI0_I1027_xan I0_pp9_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1027_MP17 (VDD XI0_I1027_xn XI0_I1027_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1027_MP6 (XI0_I1027_p1 I0_A_29_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1027_MP8 (XI0_I1027_xn I0_A_28_b3_3 XI0_I1027_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1027_MP7 (XI0_I1027_p1 I0_two9_b3_5 XI0_I1027_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1027_MP5 (VDD I0_one9_b3_5 XI0_I1027_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1027_MP10 (XI0_I1027_xan XI0_I1027_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1303_MP12 (VDD I0_B_29_b3_5 XI0_I1303_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1303_MP18 (XI0_I1303_xp1 XI0_I1303_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1303_MP20 (I0_pp14_30 I0_B_29_b3_5 XI0_I1303_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1303_MP19 (XI0_I1303_xp1 XI0_I1303_xan I0_pp14_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1303_MP17 (VDD XI0_I1303_xn XI0_I1303_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1303_MP6 (XI0_I1303_p1 I0_A_30_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1303_MP8 (XI0_I1303_xn I0_A_29_b3_5 XI0_I1303_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1303_MP7 (XI0_I1303_p1 I0_two14_b3_5 XI0_I1303_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1303_MP5 (VDD I0_one14_b3_5 XI0_I1303_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1303_MP10 (XI0_I1303_xan XI0_I1303_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1355_MP12 (VDD I0_B_31_b3_4 XI0_I1355_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1355_MP18 (XI0_I1355_xp1 XI0_I1355_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1355_MP20 (I0_pp15_27 I0_B_31_b3_4 XI0_I1355_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1355_MP19 (XI0_I1355_xp1 XI0_I1355_xan I0_pp15_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1355_MP17 (VDD XI0_I1355_xn XI0_I1355_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1355_MP6 (XI0_I1355_p1 I0_A_27_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1355_MP8 (XI0_I1355_xn I0_A_26_b3_5 XI0_I1355_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1355_MP7 (XI0_I1355_p1 I0_two15_b3_4 XI0_I1355_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1355_MP5 (VDD I0_one15_b3_4 XI0_I1355_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1355_MP10 (XI0_I1355_xan XI0_I1355_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1356_MP12 (VDD I0_B_31_b3_4 XI0_I1356_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1356_MP18 (XI0_I1356_xp1 XI0_I1356_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1356_MP20 (I0_pp15_28 I0_B_31_b3_4 XI0_I1356_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1356_MP19 (XI0_I1356_xp1 XI0_I1356_xan I0_pp15_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1356_MP17 (VDD XI0_I1356_xn XI0_I1356_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1356_MP6 (XI0_I1356_p1 I0_A_28_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1356_MP8 (XI0_I1356_xn I0_A_27_b3_5 XI0_I1356_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1356_MP7 (XI0_I1356_p1 I0_two15_b3_5 XI0_I1356_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1356_MP5 (VDD I0_one15_b3_5 XI0_I1356_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1356_MP10 (XI0_I1356_xan XI0_I1356_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1354_MP12 (VDD I0_B_31_b3_4 XI0_I1354_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1354_MP18 (XI0_I1354_xp1 XI0_I1354_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1354_MP20 (I0_pp15_26 I0_B_31_b3_4 XI0_I1354_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1354_MP19 (XI0_I1354_xp1 XI0_I1354_xan I0_pp15_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1354_MP17 (VDD XI0_I1354_xn XI0_I1354_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1354_MP6 (XI0_I1354_p1 I0_A_26_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1354_MP8 (XI0_I1354_xn I0_A_25_b3_5 XI0_I1354_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1354_MP7 (XI0_I1354_p1 I0_two15_b3_4 XI0_I1354_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1354_MP5 (VDD I0_one15_b3_4 XI0_I1354_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1354_MP10 (XI0_I1354_xan XI0_I1354_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1350_MP12 (VDD I0_B_31_b3_3 XI0_I1350_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1350_MP18 (XI0_I1350_xp1 XI0_I1350_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1350_MP20 (I0_pp15_22 I0_B_31_b3_3 XI0_I1350_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1350_MP19 (XI0_I1350_xp1 XI0_I1350_xan I0_pp15_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1350_MP17 (VDD XI0_I1350_xn XI0_I1350_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1350_MP6 (XI0_I1350_p1 I0_A_22_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1350_MP8 (XI0_I1350_xn I0_A_21_b3_5 XI0_I1350_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1350_MP7 (XI0_I1350_p1 I0_two15_b3_4 XI0_I1350_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1350_MP5 (VDD I0_one15_b3_4 XI0_I1350_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1350_MP10 (XI0_I1350_xan XI0_I1350_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1349_MP12 (VDD I0_B_31_b3_3 XI0_I1349_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1349_MP18 (XI0_I1349_xp1 XI0_I1349_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1349_MP20 (I0_pp15_21 I0_B_31_b3_3 XI0_I1349_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1349_MP19 (XI0_I1349_xp1 XI0_I1349_xan I0_pp15_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1349_MP17 (VDD XI0_I1349_xn XI0_I1349_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1349_MP6 (XI0_I1349_p1 I0_A_21_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1349_MP8 (XI0_I1349_xn I0_A_20_b3_5 XI0_I1349_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1349_MP7 (XI0_I1349_p1 I0_two15_b3_3 XI0_I1349_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1349_MP5 (VDD I0_one15_b3_3 XI0_I1349_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1349_MP10 (XI0_I1349_xan XI0_I1349_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1295_MP12 (VDD I0_B_29_b3_3 XI0_I1295_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1295_MP18 (XI0_I1295_xp1 XI0_I1295_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1295_MP20 (I0_pp14_22 I0_B_29_b3_3 XI0_I1295_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1295_MP19 (XI0_I1295_xp1 XI0_I1295_xan I0_pp14_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1295_MP17 (VDD XI0_I1295_xn XI0_I1295_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1295_MP6 (XI0_I1295_p1 I0_A_22_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1295_MP8 (XI0_I1295_xn I0_A_21_b3_5 XI0_I1295_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1295_MP7 (XI0_I1295_p1 I0_two14_b3_4 XI0_I1295_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1295_MP5 (VDD I0_one14_b3_4 XI0_I1295_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1295_MP10 (XI0_I1295_xan XI0_I1295_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1188_MP12 (VDD I0_B_25_b3_4 XI0_I1188_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1188_MP18 (XI0_I1188_xp1 XI0_I1188_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1188_MP20 (I0_pp12_25 I0_B_25_b3_4 XI0_I1188_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1188_MP19 (XI0_I1188_xp1 XI0_I1188_xan I0_pp12_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1188_MP17 (VDD XI0_I1188_xn XI0_I1188_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1188_MP6 (XI0_I1188_p1 I0_A_25_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1188_MP8 (XI0_I1188_xn I0_A_24_b3_4 XI0_I1188_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1188_MP7 (XI0_I1188_p1 I0_two12_b3_4 XI0_I1188_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1188_MP5 (VDD I0_one12_b3_4 XI0_I1188_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1188_MP10 (XI0_I1188_xan XI0_I1188_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1347_MP12 (VDD I0_B_31_b3_3 XI0_I1347_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1347_MP18 (XI0_I1347_xp1 XI0_I1347_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1347_MP20 (I0_pp15_19 I0_B_31_b3_3 XI0_I1347_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1347_MP19 (XI0_I1347_xp1 XI0_I1347_xan I0_pp15_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1347_MP17 (VDD XI0_I1347_xn XI0_I1347_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1347_MP6 (XI0_I1347_p1 I0_A_19_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1347_MP8 (XI0_I1347_xn I0_A_18_b3_5 XI0_I1347_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1347_MP7 (XI0_I1347_p1 I0_two15_b3_3 XI0_I1347_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1347_MP5 (VDD I0_one15_b3_3 XI0_I1347_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1347_MP10 (XI0_I1347_xan XI0_I1347_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1348_MP12 (VDD I0_B_31_b3_3 XI0_I1348_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1348_MP18 (XI0_I1348_xp1 XI0_I1348_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1348_MP20 (I0_pp15_20 I0_B_31_b3_3 XI0_I1348_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1348_MP19 (XI0_I1348_xp1 XI0_I1348_xan I0_pp15_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1348_MP17 (VDD XI0_I1348_xn XI0_I1348_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1348_MP6 (XI0_I1348_p1 I0_A_20_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1348_MP8 (XI0_I1348_xn I0_A_19_b3_5 XI0_I1348_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1348_MP7 (XI0_I1348_p1 I0_two15_b3_3 XI0_I1348_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1348_MP5 (VDD I0_one15_b3_3 XI0_I1348_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1348_MP10 (XI0_I1348_xan XI0_I1348_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1187_MP12 (VDD I0_B_25_b3_4 XI0_I1187_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1187_MP18 (XI0_I1187_xp1 XI0_I1187_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1187_MP20 (I0_pp12_24 I0_B_25_b3_4 XI0_I1187_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1187_MP19 (XI0_I1187_xp1 XI0_I1187_xan I0_pp12_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1187_MP17 (VDD XI0_I1187_xn XI0_I1187_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1187_MP6 (XI0_I1187_p1 I0_A_24_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1187_MP8 (XI0_I1187_xn I0_A_23_b3_4 XI0_I1187_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1187_MP7 (XI0_I1187_p1 I0_two12_b3_4 XI0_I1187_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1187_MP5 (VDD I0_one12_b3_4 XI0_I1187_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1187_MP10 (XI0_I1187_xan XI0_I1187_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1134_MP12 (VDD I0_B_23_b3_4 XI0_I1134_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1134_MP18 (XI0_I1134_xp1 XI0_I1134_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1134_MP20 (I0_pp11_26 I0_B_23_b3_4 XI0_I1134_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1134_MP19 (XI0_I1134_xp1 XI0_I1134_xan I0_pp11_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1134_MP17 (VDD XI0_I1134_xn XI0_I1134_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1134_MP6 (XI0_I1134_p1 I0_A_26_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1134_MP8 (XI0_I1134_xn I0_A_25_b3_4 XI0_I1134_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1134_MP7 (XI0_I1134_p1 I0_two11_b3_4 XI0_I1134_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1134_MP5 (VDD I0_one11_b3_4 XI0_I1134_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1134_MP10 (XI0_I1134_xan XI0_I1134_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1029_MP12 (VDD I0_B_19_b3_5 XI0_I1029_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1029_MP18 (XI0_I1029_xp1 XI0_I1029_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1029_MP20 (I0_pp9_31 I0_B_19_b3_5 XI0_I1029_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1029_MP19 (XI0_I1029_xp1 XI0_I1029_xan I0_pp9_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1029_MP17 (VDD XI0_I1029_xn XI0_I1029_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1029_MP6 (XI0_I1029_p1 I0_A_31_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1029_MP8 (XI0_I1029_xn I0_A_30_b3_3 XI0_I1029_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1029_MP7 (XI0_I1029_p1 I0_two9_b3_5 XI0_I1029_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1029_MP5 (VDD I0_one9_b3_5 XI0_I1029_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1029_MP10 (XI0_I1029_xan XI0_I1029_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I974_MP12 (VDD I0_B_17_b3_5 XI0_I974_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I974_MP18 (XI0_I974_xp1 XI0_I974_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I974_MP20 (I0_pp8_31 I0_B_17_b3_5 XI0_I974_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I974_MP19 (XI0_I974_xp1 XI0_I974_xan I0_pp8_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I974_MP17 (VDD XI0_I974_xn XI0_I974_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I974_MP6 (XI0_I974_p1 I0_A_31_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I974_MP8 (XI0_I974_xn I0_A_30_b3_3 XI0_I974_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I974_MP7 (XI0_I974_p1 I0_two8_b3_5 XI0_I974_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I974_MP5 (VDD I0_one8_b3_5 XI0_I974_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I974_MP10 (XI0_I974_xan XI0_I974_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I975_MP12 (VDD I0_B_17_b3_5 XI0_I975_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I975_MP18 (XI0_I975_xp1 XI0_I975_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I975_MP20 (I0_pp8_32 I0_B_17_b3_5 XI0_I975_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I975_MP19 (XI0_I975_xp1 XI0_I975_xan I0_pp8_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I975_MP17 (VDD XI0_I975_xn XI0_I975_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I975_MP6 (XI0_I975_p1 I0_A_31_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I975_MP8 (XI0_I975_xn I0_A_31_b3_4 XI0_I975_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I975_MP7 (XI0_I975_p1 I0_two8_b3_5 XI0_I975_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I975_MP5 (VDD I0_one8_b3_5 XI0_I975_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I975_MP10 (XI0_I975_xan XI0_I975_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1305_MP12 (VDD I0_B_29_b3_5 XI0_I1305_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1305_MP18 (XI0_I1305_xp1 XI0_I1305_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1305_MP20 (I0_pp14_32 I0_B_29_b3_5 XI0_I1305_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1305_MP19 (XI0_I1305_xp1 XI0_I1305_xan I0_pp14_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1305_MP17 (VDD XI0_I1305_xn XI0_I1305_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1305_MP6 (XI0_I1305_p1 I0_A_31_b3_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1305_MP8 (XI0_I1305_xn I0_A_31_b3_7 XI0_I1305_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1305_MP7 (XI0_I1305_p1 I0_two14_b3_5 XI0_I1305_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1305_MP5 (VDD I0_one14_b3_5 XI0_I1305_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1305_MP10 (XI0_I1305_xan XI0_I1305_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1304_MP12 (VDD I0_B_29_b3_5 XI0_I1304_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1304_MP18 (XI0_I1304_xp1 XI0_I1304_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1304_MP20 (I0_pp14_31 I0_B_29_b3_5 XI0_I1304_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1304_MP19 (XI0_I1304_xp1 XI0_I1304_xan I0_pp14_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1304_MP17 (VDD XI0_I1304_xn XI0_I1304_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1304_MP6 (XI0_I1304_p1 I0_A_31_b3_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1304_MP8 (XI0_I1304_xn I0_A_30_b3_5 XI0_I1304_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1304_MP7 (XI0_I1304_p1 I0_two14_b3_5 XI0_I1304_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1304_MP5 (VDD I0_one14_b3_5 XI0_I1304_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1304_MP10 (XI0_I1304_xan XI0_I1304_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1353_MP12 (VDD I0_B_31_b3_4 XI0_I1353_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1353_MP18 (XI0_I1353_xp1 XI0_I1353_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1353_MP20 (I0_pp15_25 I0_B_31_b3_4 XI0_I1353_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1353_MP19 (XI0_I1353_xp1 XI0_I1353_xan I0_pp15_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1353_MP17 (VDD XI0_I1353_xn XI0_I1353_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1353_MP6 (XI0_I1353_p1 I0_A_25_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1353_MP8 (XI0_I1353_xn I0_A_24_b3_5 XI0_I1353_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1353_MP7 (XI0_I1353_p1 I0_two15_b3_4 XI0_I1353_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1353_MP5 (VDD I0_one15_b3_4 XI0_I1353_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1353_MP10 (XI0_I1353_xan XI0_I1353_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1357_MP12 (VDD I0_B_31_b3_5 XI0_I1357_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1357_MP18 (XI0_I1357_xp1 XI0_I1357_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1357_MP20 (I0_pp15_29 I0_B_31_b3_5 XI0_I1357_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1357_MP19 (XI0_I1357_xp1 XI0_I1357_xan I0_pp15_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1357_MP17 (VDD XI0_I1357_xn XI0_I1357_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1357_MP6 (XI0_I1357_p1 I0_A_29_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1357_MP8 (XI0_I1357_xn I0_A_28_b3_5 XI0_I1357_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1357_MP7 (XI0_I1357_p1 I0_two15_b3_5 XI0_I1357_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1357_MP5 (VDD I0_one15_b3_5 XI0_I1357_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1357_MP10 (XI0_I1357_xan XI0_I1357_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1352_MP12 (VDD I0_B_31_b3_4 XI0_I1352_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1352_MP18 (XI0_I1352_xp1 XI0_I1352_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1352_MP20 (I0_pp15_24 I0_B_31_b3_4 XI0_I1352_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1352_MP19 (XI0_I1352_xp1 XI0_I1352_xan I0_pp15_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1352_MP17 (VDD XI0_I1352_xn XI0_I1352_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1352_MP6 (XI0_I1352_p1 I0_A_24_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1352_MP8 (XI0_I1352_xn I0_A_23_b3_5 XI0_I1352_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1352_MP7 (XI0_I1352_p1 I0_two15_b3_4 XI0_I1352_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1352_MP5 (VDD I0_one15_b3_4 XI0_I1352_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1352_MP10 (XI0_I1352_xan XI0_I1352_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1299_MP12 (VDD I0_B_29_b3_4 XI0_I1299_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1299_MP18 (XI0_I1299_xp1 XI0_I1299_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1299_MP20 (I0_pp14_26 I0_B_29_b3_4 XI0_I1299_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1299_MP19 (XI0_I1299_xp1 XI0_I1299_xan I0_pp14_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1299_MP17 (VDD XI0_I1299_xn XI0_I1299_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1299_MP6 (XI0_I1299_p1 I0_A_26_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1299_MP8 (XI0_I1299_xn I0_A_25_b3_5 XI0_I1299_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1299_MP7 (XI0_I1299_p1 I0_two14_b3_4 XI0_I1299_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1299_MP5 (VDD I0_one14_b3_4 XI0_I1299_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1299_MP10 (XI0_I1299_xan XI0_I1299_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1298_MP12 (VDD I0_B_29_b3_4 XI0_I1298_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1298_MP18 (XI0_I1298_xp1 XI0_I1298_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1298_MP20 (I0_pp14_25 I0_B_29_b3_4 XI0_I1298_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1298_MP19 (XI0_I1298_xp1 XI0_I1298_xan I0_pp14_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1298_MP17 (VDD XI0_I1298_xn XI0_I1298_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1298_MP6 (XI0_I1298_p1 I0_A_25_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1298_MP8 (XI0_I1298_xn I0_A_24_b3_5 XI0_I1298_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1298_MP7 (XI0_I1298_p1 I0_two14_b3_4 XI0_I1298_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1298_MP5 (VDD I0_one14_b3_4 XI0_I1298_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1298_MP10 (XI0_I1298_xan XI0_I1298_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1243_MP12 (VDD I0_B_27_b3_4 XI0_I1243_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1243_MP18 (XI0_I1243_xp1 XI0_I1243_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1243_MP20 (I0_pp13_25 I0_B_27_b3_4 XI0_I1243_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1243_MP19 (XI0_I1243_xp1 XI0_I1243_xan I0_pp13_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1243_MP17 (VDD XI0_I1243_xn XI0_I1243_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1243_MP6 (XI0_I1243_p1 I0_A_25_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1243_MP8 (XI0_I1243_xn I0_A_24_b3_5 XI0_I1243_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1243_MP7 (XI0_I1243_p1 I0_two13_b3_4 XI0_I1243_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1243_MP5 (VDD I0_one13_b3_4 XI0_I1243_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1243_MP10 (XI0_I1243_xan XI0_I1243_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1296_MP12 (VDD I0_B_29_b3_4 XI0_I1296_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1296_MP18 (XI0_I1296_xp1 XI0_I1296_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1296_MP20 (I0_pp14_23 I0_B_29_b3_4 XI0_I1296_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1296_MP19 (XI0_I1296_xp1 XI0_I1296_xan I0_pp14_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1296_MP17 (VDD XI0_I1296_xn XI0_I1296_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1296_MP6 (XI0_I1296_p1 I0_A_23_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1296_MP8 (XI0_I1296_xn I0_A_22_b3_5 XI0_I1296_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1296_MP7 (XI0_I1296_p1 I0_two14_b3_4 XI0_I1296_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1296_MP5 (VDD I0_one14_b3_4 XI0_I1296_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1296_MP10 (XI0_I1296_xan XI0_I1296_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1241_MP12 (VDD I0_B_27_b3_4 XI0_I1241_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1241_MP18 (XI0_I1241_xp1 XI0_I1241_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1241_MP20 (I0_pp13_23 I0_B_27_b3_4 XI0_I1241_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1241_MP19 (XI0_I1241_xp1 XI0_I1241_xan I0_pp13_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1241_MP17 (VDD XI0_I1241_xn XI0_I1241_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1241_MP6 (XI0_I1241_p1 I0_A_23_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1241_MP8 (XI0_I1241_xn I0_A_22_b3_5 XI0_I1241_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1241_MP7 (XI0_I1241_p1 I0_two13_b3_4 XI0_I1241_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1241_MP5 (VDD I0_one13_b3_4 XI0_I1241_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1241_MP10 (XI0_I1241_xan XI0_I1241_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1244_MP12 (VDD I0_B_27_b3_4 XI0_I1244_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1244_MP18 (XI0_I1244_xp1 XI0_I1244_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1244_MP20 (I0_pp13_26 I0_B_27_b3_4 XI0_I1244_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1244_MP19 (XI0_I1244_xp1 XI0_I1244_xan I0_pp13_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1244_MP17 (VDD XI0_I1244_xn XI0_I1244_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1244_MP6 (XI0_I1244_p1 I0_A_26_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1244_MP8 (XI0_I1244_xn I0_A_25_b3_5 XI0_I1244_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1244_MP7 (XI0_I1244_p1 I0_two13_b3_4 XI0_I1244_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1244_MP5 (VDD I0_one13_b3_4 XI0_I1244_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1244_MP10 (XI0_I1244_xan XI0_I1244_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1242_MP12 (VDD I0_B_27_b3_4 XI0_I1242_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1242_MP18 (XI0_I1242_xp1 XI0_I1242_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1242_MP20 (I0_pp13_24 I0_B_27_b3_4 XI0_I1242_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1242_MP19 (XI0_I1242_xp1 XI0_I1242_xan I0_pp13_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1242_MP17 (VDD XI0_I1242_xn XI0_I1242_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1242_MP6 (XI0_I1242_p1 I0_A_24_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1242_MP8 (XI0_I1242_xn I0_A_23_b3_5 XI0_I1242_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1242_MP7 (XI0_I1242_p1 I0_two13_b3_4 XI0_I1242_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1242_MP5 (VDD I0_one13_b3_4 XI0_I1242_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1242_MP10 (XI0_I1242_xan XI0_I1242_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1189_MP12 (VDD I0_B_25_b3_4 XI0_I1189_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1189_MP18 (XI0_I1189_xp1 XI0_I1189_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1189_MP20 (I0_pp12_26 I0_B_25_b3_4 XI0_I1189_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1189_MP19 (XI0_I1189_xp1 XI0_I1189_xan I0_pp12_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1189_MP17 (VDD XI0_I1189_xn XI0_I1189_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1189_MP6 (XI0_I1189_p1 I0_A_26_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1189_MP8 (XI0_I1189_xn I0_A_25_b3_4 XI0_I1189_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1189_MP7 (XI0_I1189_p1 I0_two12_b3_4 XI0_I1189_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1189_MP5 (VDD I0_one12_b3_4 XI0_I1189_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1189_MP10 (XI0_I1189_xan XI0_I1189_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1190_MP12 (VDD I0_B_25_b3_4 XI0_I1190_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1190_MP18 (XI0_I1190_xp1 XI0_I1190_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1190_MP20 (I0_pp12_27 I0_B_25_b3_4 XI0_I1190_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1190_MP19 (XI0_I1190_xp1 XI0_I1190_xan I0_pp12_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1190_MP17 (VDD XI0_I1190_xn XI0_I1190_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1190_MP6 (XI0_I1190_p1 I0_A_27_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1190_MP8 (XI0_I1190_xn I0_A_26_b3_4 XI0_I1190_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1190_MP7 (XI0_I1190_p1 I0_two12_b3_4 XI0_I1190_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1190_MP5 (VDD I0_one12_b3_4 XI0_I1190_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1190_MP10 (XI0_I1190_xan XI0_I1190_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1135_MP12 (VDD I0_B_23_b3_4 XI0_I1135_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1135_MP18 (XI0_I1135_xp1 XI0_I1135_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1135_MP20 (I0_pp11_27 I0_B_23_b3_4 XI0_I1135_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1135_MP19 (XI0_I1135_xp1 XI0_I1135_xan I0_pp11_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1135_MP17 (VDD XI0_I1135_xn XI0_I1135_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1135_MP6 (XI0_I1135_p1 I0_A_27_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1135_MP8 (XI0_I1135_xn I0_A_26_b3_4 XI0_I1135_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1135_MP7 (XI0_I1135_p1 I0_two11_b3_4 XI0_I1135_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1135_MP5 (VDD I0_one11_b3_4 XI0_I1135_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1135_MP10 (XI0_I1135_xan XI0_I1135_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1030_MP12 (VDD I0_B_19_b3_5 XI0_I1030_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1030_MP18 (XI0_I1030_xp1 XI0_I1030_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1030_MP20 (I0_pp9_32 I0_B_19_b3_5 XI0_I1030_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1030_MP19 (XI0_I1030_xp1 XI0_I1030_xan I0_pp9_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1030_MP17 (VDD XI0_I1030_xn XI0_I1030_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1030_MP6 (XI0_I1030_p1 I0_A_31_b3_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1030_MP8 (XI0_I1030_xn I0_A_31_b3_4 XI0_I1030_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1030_MP7 (XI0_I1030_p1 I0_two9_b3_5 XI0_I1030_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1030_MP5 (VDD I0_one9_b3_5 XI0_I1030_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1030_MP10 (XI0_I1030_xan XI0_I1030_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1028_MP12 (VDD I0_B_19_b3_5 XI0_I1028_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1028_MP18 (XI0_I1028_xp1 XI0_I1028_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1028_MP20 (I0_pp9_30 I0_B_19_b3_5 XI0_I1028_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1028_MP19 (XI0_I1028_xp1 XI0_I1028_xan I0_pp9_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1028_MP17 (VDD XI0_I1028_xn XI0_I1028_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1028_MP6 (XI0_I1028_p1 I0_A_30_b3_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1028_MP8 (XI0_I1028_xn I0_A_29_b3_3 XI0_I1028_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1028_MP7 (XI0_I1028_p1 I0_two9_b3_5 XI0_I1028_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1028_MP5 (VDD I0_one9_b3_5 XI0_I1028_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1028_MP10 (XI0_I1028_xan XI0_I1028_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1351_MP12 (VDD I0_B_31_b3_4 XI0_I1351_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1351_MP18 (XI0_I1351_xp1 XI0_I1351_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1351_MP20 (I0_pp15_23 I0_B_31_b3_4 XI0_I1351_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1351_MP19 (XI0_I1351_xp1 XI0_I1351_xan I0_pp15_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1351_MP17 (VDD XI0_I1351_xn XI0_I1351_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1351_MP6 (XI0_I1351_p1 I0_A_23_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1351_MP8 (XI0_I1351_xn I0_A_22_b3_5 XI0_I1351_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1351_MP7 (XI0_I1351_p1 I0_two15_b3_4 XI0_I1351_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1351_MP5 (VDD I0_one15_b3_4 XI0_I1351_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1351_MP10 (XI0_I1351_xan XI0_I1351_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1297_MP12 (VDD I0_B_29_b3_4 XI0_I1297_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1297_MP18 (XI0_I1297_xp1 XI0_I1297_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1297_MP20 (I0_pp14_24 I0_B_29_b3_4 XI0_I1297_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1297_MP19 (XI0_I1297_xp1 XI0_I1297_xan I0_pp14_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1297_MP17 (VDD XI0_I1297_xn XI0_I1297_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1297_MP6 (XI0_I1297_p1 I0_A_24_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1297_MP8 (XI0_I1297_xn I0_A_23_b3_5 XI0_I1297_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1297_MP7 (XI0_I1297_p1 I0_two14_b3_4 XI0_I1297_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1297_MP5 (VDD I0_one14_b3_4 XI0_I1297_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1297_MP10 (XI0_I1297_xan XI0_I1297_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1358_MP12 (VDD I0_B_31_b3_5 XI0_I1358_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1358_MP18 (XI0_I1358_xp1 XI0_I1358_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1358_MP20 (I0_pp15_30 I0_B_31_b3_5 XI0_I1358_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1358_MP19 (XI0_I1358_xp1 XI0_I1358_xan I0_pp15_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1358_MP17 (VDD XI0_I1358_xn XI0_I1358_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1358_MP6 (XI0_I1358_p1 I0_A_30_b3_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1358_MP8 (XI0_I1358_xn I0_A_29_b3_5 XI0_I1358_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1358_MP7 (XI0_I1358_p1 I0_two15_b3_5 XI0_I1358_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1358_MP5 (VDD I0_one15_b3_5 XI0_I1358_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1358_MP10 (XI0_I1358_xan XI0_I1358_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1359_MP12 (VDD I0_B_31_b3_5 XI0_I1359_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1359_MP18 (XI0_I1359_xp1 XI0_I1359_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1359_MP20 (I0_pp15_31 I0_B_31_b3_5 XI0_I1359_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1359_MP19 (XI0_I1359_xp1 XI0_I1359_xan I0_pp15_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1359_MP17 (VDD XI0_I1359_xn XI0_I1359_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1359_MP6 (XI0_I1359_p1 I0_A_31_b3_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1359_MP8 (XI0_I1359_xn I0_A_30_b3_5 XI0_I1359_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1359_MP7 (XI0_I1359_p1 I0_two15_b3_5 XI0_I1359_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1359_MP5 (VDD I0_one15_b3_5 XI0_I1359_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1359_MP10 (XI0_I1359_xan XI0_I1359_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1360_MP12 (VDD I0_B_31_b3_5 XI0_I1360_xbn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI0_I1360_MP18 (XI0_I1360_xp1 XI0_I1360_xbn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1360_MP20 (I0_pp15_32 I0_B_31_b3_5 XI0_I1360_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1360_MP19 (XI0_I1360_xp1 XI0_I1360_xan I0_pp15_32 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1360_MP17 (VDD XI0_I1360_xn XI0_I1360_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1360_MP6 (XI0_I1360_p1 I0_A_31_b3_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.16316p pd=0.91999u ps=1.63999u
    I_MXI0_I1360_MP8 (XI0_I1360_xn I0_A_31_b3_7 XI0_I1360_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1360_MP7 (XI0_I1360_p1 I0_two15_b3_5 XI0_I1360_xn VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.10556p as=0.10556p pd=0.91999u ps=0.91999u
    I_MXI0_I1360_MP5 (VDD I0_one15_b3_5 XI0_I1360_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.16316p as=0.10556p pd=1.63999u ps=0.91999u
    I_MXI0_I1360_MP10 (XI0_I1360_xan XI0_I1360_xn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.08156p pd=1.15999u ps=1.15999u
    I_MXI1_I1344_I30_MP1 (I1_I1344_gn30 I1_b17_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I30_MP0 (VDD I1_p16_29 I1_I1344_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I31_MP1 (I1_I1344_gn31 I1_b17_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I31_MP0 (VDD I1_p16_30 I1_I1344_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I182_XP_MP1 (I1_I1344_P31_16n I1_I1344_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I182_XP_MP0 (VDD I1_I1344_P31_24 I1_I1344_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I127_XP_MP1 (I1_I1298_P31_28n I1_I1298_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I127_XP_MP0 (VDD I1_I1298_P31_30 I1_I1298_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I29_MP1 (I1_I1298_gn29 I1_b16_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I29_MP0 (VDD I1_p15_28 I1_I1298_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I28_MP1 (I1_I1298_gn28 I1_b16_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I28_MP0 (VDD I1_p15_27 I1_I1298_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I30_MP1 (I1_I1298_gn30 I1_b16_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I30_MP0 (VDD I1_p15_29 I1_I1298_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I31_MP1 (I1_I1298_gn31 I1_b16_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I31_MP0 (VDD I1_p15_30 I1_I1298_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I127_XP_MP1 (I1_I1252_P31_28n I1_I1252_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I127_XP_MP0 (VDD I1_I1252_P31_30 I1_I1252_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I28_MP1 (I1_I1252_gn28 I1_b15_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I28_MP0 (VDD I1_p14_27 I1_I1252_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I29_MP1 (I1_I1252_gn29 I1_b15_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I29_MP0 (VDD I1_p14_28 I1_I1252_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I31_MP1 (I1_I1252_gn31 I1_b15_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I31_MP0 (VDD I1_p14_30 I1_I1252_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I30_MP1 (I1_I1252_gn30 I1_b15_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I30_MP0 (VDD I1_p14_29 I1_I1252_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I29_MP1 (I1_I1206_gn29 I1_b14_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I29_MP0 (VDD I1_p13_28 I1_I1206_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I28_MP1 (I1_I1206_gn28 I1_b14_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I28_MP0 (VDD I1_p13_27 I1_I1206_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I27_MP1 (I1_I1206_gn27 I1_b14_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I27_MP0 (VDD I1_p13_26 I1_I1206_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I29_MP1 (I1_I838_gn29 I1_b6_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I29_MP0 (VDD I1_p5_28 I1_I838_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I30_MP1 (I1_I838_gn30 I1_b6_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I30_MP0 (VDD I1_p5_29 I1_I838_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I31_MP1 (I1_I838_gn31 I1_b6_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I31_MP0 (VDD I1_p5_30 I1_I838_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I125_XP_MP1 (I1_I838_P29_26n I1_I838_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I125_XP_MP0 (VDD I1_I838_P29_28 I1_I838_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I127_XP_MP1 (I1_I838_P31_28n I1_I838_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I127_XP_MP0 (VDD I1_I838_P31_30 I1_I838_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I123_XP_MP1 (I1_I838_P27_24n I1_I838_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I123_XP_MP0 (VDD I1_I838_P27_26 I1_I838_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I180_XP_MP1 (I1_I838_P29_14n I1_I838_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I180_XP_MP0 (VDD I1_I838_P29_22 I1_I838_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I178_XP_MP1 (I1_I838_P27_12n I1_I838_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I178_XP_MP0 (VDD I1_I838_P27_20 I1_I838_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I182_XP_MP1 (I1_I838_P31_16n I1_I838_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I182_XP_MP0 (VDD I1_I838_P31_24 I1_I838_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I174_XP_MP1 (I1_I838_P23_8n I1_I838_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I174_XP_MP0 (VDD I1_I838_P23_16 I1_I838_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I172_XP_MP1 (I1_I838_P21_6n I1_I838_P13_6 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I172_XP_MP0 (VDD I1_I838_P21_14 I1_I838_P21_6n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I170_XP_MP1 (I1_I838_P19_4n I1_I838_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I170_XP_MP0 (VDD I1_I838_P19_12 I1_I838_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I178_XP_MP1 (I1_I792_P27_12n I1_I792_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I178_XP_MP0 (VDD I1_I792_P27_20 I1_I792_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I182_XP_MP1 (I1_I792_P31_16n I1_I792_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I182_XP_MP0 (VDD I1_I792_P31_24 I1_I792_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I123_XP_MP1 (I1_I792_P27_24n I1_I792_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I123_XP_MP0 (VDD I1_I792_P27_26 I1_I792_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I125_XP_MP1 (I1_I792_P29_26n I1_I792_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I125_XP_MP0 (VDD I1_I792_P29_28 I1_I792_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I127_XP_MP1 (I1_I792_P31_28n I1_I792_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I127_XP_MP0 (VDD I1_I792_P31_30 I1_I792_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I124_XP_MP1 (I1_I792_P28_25n I1_I792_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I124_XP_MP0 (VDD I1_I792_P28_27 I1_I792_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I126_XP_MP1 (I1_I792_P30_27n I1_I792_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I126_XP_MP0 (VDD I1_I792_P30_29 I1_I792_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I30_MP1 (I1_I792_gn30 I1_b5_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I30_MP0 (VDD I1_p4_29 I1_I792_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I31_MP1 (I1_I792_gn31 I1_b5_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I31_MP0 (VDD I1_p4_30 I1_I792_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I28_MP1 (I1_I792_gn28 I1_b5_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I28_MP0 (VDD I1_p4_27 I1_I792_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I27_MP1 (I1_I792_gn27 I1_b5_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I27_MP0 (VDD I1_p4_26 I1_I792_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I29_MP1 (I1_I792_gn29 I1_b5_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I29_MP0 (VDD I1_p4_28 I1_I792_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I28_MP1 (I1_I1344_gn28 I1_b17_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I28_MP0 (VDD I1_p16_27 I1_I1344_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I29_MP1 (I1_I1344_gn29 I1_b17_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I29_MP0 (VDD I1_p16_28 I1_I1344_gn29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I125_XP_MP1 (I1_I1344_P29_26n I1_I1344_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I125_XP_MP0 (VDD I1_I1344_P29_28 I1_I1344_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I127_XP_MP1 (I1_I1344_P31_28n I1_I1344_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I127_XP_MP0 (VDD I1_I1344_P31_30 I1_I1344_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I123_XP_MP1 (I1_I1344_P27_24n I1_I1344_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I123_XP_MP0 (VDD I1_I1344_P27_26 I1_I1344_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I174_XP_MP1 (I1_I1344_P23_8n I1_I1344_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I174_XP_MP0 (VDD I1_I1344_P23_16 I1_I1344_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I182_XP_MP1 (I1_I1298_P31_16n I1_I1298_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I182_XP_MP0 (VDD I1_I1298_P31_24 I1_I1298_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I125_XP_MP1 (I1_I1298_P29_26n I1_I1298_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I125_XP_MP0 (VDD I1_I1298_P29_28 I1_I1298_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I123_XP_MP1 (I1_I1298_P27_24n I1_I1298_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I123_XP_MP0 (VDD I1_I1298_P27_26 I1_I1298_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I126_XP_MP1 (I1_I1298_P30_27n I1_I1298_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I126_XP_MP0 (VDD I1_I1298_P30_29 I1_I1298_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I27_MP1 (I1_I1298_gn27 I1_b16_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I27_MP0 (VDD I1_p15_26 I1_I1298_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I26_MP1 (I1_I1298_gn26 I1_b16_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I26_MP0 (VDD I1_p15_25 I1_I1298_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I181_XP_MP1 (I1_I1252_P30_15n I1_I1252_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I181_XP_MP0 (VDD I1_I1252_P30_23 I1_I1252_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I124_XP_MP1 (I1_I1252_P28_25n I1_I1252_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I124_XP_MP0 (VDD I1_I1252_P28_27 I1_I1252_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I126_XP_MP1 (I1_I1252_P30_27n I1_I1252_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I126_XP_MP0 (VDD I1_I1252_P30_29 I1_I1252_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I125_XP_MP1 (I1_I1252_P29_26n I1_I1252_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I125_XP_MP0 (VDD I1_I1252_P29_28 I1_I1252_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I27_MP1 (I1_I1252_gn27 I1_b15_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I27_MP0 (VDD I1_p14_26 I1_I1252_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I26_MP1 (I1_I1252_gn26 I1_b15_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I26_MP0 (VDD I1_p14_25 I1_I1252_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I127_XP_MP1 (I1_I1206_P31_28n I1_I1206_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I127_XP_MP0 (VDD I1_I1206_P31_30 I1_I1206_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I126_XP_MP1 (I1_I1206_P30_27n I1_I1206_P28_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I126_XP_MP0 (VDD I1_I1206_P30_29 I1_I1206_P30_27n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I28_MP1 (I1_I838_gn28 I1_b6_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I28_MP0 (VDD I1_p5_27 I1_I838_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I25_MP1 (I1_I838_gn25 I1_b6_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I25_MP0 (VDD I1_p5_24 I1_I838_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I121_XP_MP1 (I1_I838_P25_22n I1_I838_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I121_XP_MP0 (VDD I1_I838_P25_24 I1_I838_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I119_XP_MP1 (I1_I838_P23_20n I1_I838_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I119_XP_MP0 (VDD I1_I838_P23_22 I1_I838_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I117_XP_MP1 (I1_I838_P21_18n I1_I838_P19_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I117_XP_MP0 (VDD I1_I838_P21_20 I1_I838_P21_18n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I115_XP_MP1 (I1_I838_P19_16n I1_I838_P17_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I115_XP_MP0 (VDD I1_I838_P19_18 I1_I838_P19_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I113_XP_MP1 (I1_I838_P17_14n I1_I838_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I113_XP_MP0 (VDD I1_I838_P17_16 I1_I838_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I111_XP_MP1 (I1_I838_P15_12n I1_I838_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I111_XP_MP0 (VDD I1_I838_P15_14 I1_I838_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I168_XP_MP1 (I1_I838_P17_2n I1_I838_P9_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I168_XP_MP0 (VDD I1_I838_P17_10 I1_I838_P17_2n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I180_XP_MP1 (I1_I792_P29_14n I1_I792_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I180_XP_MP0 (VDD I1_I792_P29_22 I1_I792_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I176_XP_MP1 (I1_I792_P25_10n I1_I792_P17_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I176_XP_MP0 (VDD I1_I792_P25_18 I1_I792_P25_10n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I174_XP_MP1 (I1_I792_P23_8n I1_I792_P15_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I174_XP_MP0 (VDD I1_I792_P23_16 I1_I792_P23_8n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I119_XP_MP1 (I1_I792_P23_20n I1_I792_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I119_XP_MP0 (VDD I1_I792_P23_22 I1_I792_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I121_XP_MP1 (I1_I792_P25_22n I1_I792_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I121_XP_MP0 (VDD I1_I792_P25_24 I1_I792_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I179_XP_MP1 (I1_I792_P28_13n I1_I792_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I179_XP_MP0 (VDD I1_I792_P28_21 I1_I792_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I181_XP_MP1 (I1_I792_P30_15n I1_I792_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I181_XP_MP0 (VDD I1_I792_P30_23 I1_I792_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I120_XP_MP1 (I1_I792_P24_21n I1_I792_P22_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I120_XP_MP0 (VDD I1_I792_P24_23 I1_I792_P24_21n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I122_XP_MP1 (I1_I792_P26_23n I1_I792_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I122_XP_MP0 (VDD I1_I792_P26_25 I1_I792_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I23_MP1 (I1_I792_gn23 I1_b5_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I23_MP0 (VDD I1_p4_22 I1_I792_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I26_MP1 (I1_I792_gn26 I1_b5_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I26_MP0 (VDD I1_p4_25 I1_I792_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I24_MP1 (I1_I792_gn24 I1_b5_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I24_MP0 (VDD I1_p4_23 I1_I792_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I792_I25_MP1 (I1_I792_gn25 I1_b5_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I792_I25_MP0 (VDD I1_p4_24 I1_I792_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I121_XP_MP1 (I1_I1344_P25_22n I1_I1344_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I121_XP_MP0 (VDD I1_I1344_P25_24 I1_I1344_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I119_XP_MP1 (I1_I1344_P23_20n I1_I1344_P21_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I119_XP_MP0 (VDD I1_I1344_P23_22 I1_I1344_P23_20n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I180_XP_MP1 (I1_I1344_P29_14n I1_I1344_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I180_XP_MP0 (VDD I1_I1344_P29_22 I1_I1344_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I178_XP_MP1 (I1_I1344_P27_12n I1_I1344_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I178_XP_MP0 (VDD I1_I1344_P27_20 I1_I1344_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1344_I170_XP_MP1 (I1_I1344_P19_4n I1_I1344_P11_4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1344_I170_XP_MP0 (VDD I1_I1344_P19_12 I1_I1344_P19_4n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I178_XP_MP1 (I1_I1298_P27_12n I1_I1298_P19_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I178_XP_MP0 (VDD I1_I1298_P27_20 I1_I1298_P27_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I180_XP_MP1 (I1_I1298_P29_14n I1_I1298_P21_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I180_XP_MP0 (VDD I1_I1298_P29_22 I1_I1298_P29_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I121_XP_MP1 (I1_I1298_P25_22n I1_I1298_P23_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I121_XP_MP0 (VDD I1_I1298_P25_24 I1_I1298_P25_22n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I181_XP_MP1 (I1_I1298_P30_15n I1_I1298_P22_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I181_XP_MP0 (VDD I1_I1298_P30_23 I1_I1298_P30_15n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I124_XP_MP1 (I1_I1298_P28_25n I1_I1298_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I124_XP_MP0 (VDD I1_I1298_P28_27 I1_I1298_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I122_XP_MP1 (I1_I1298_P26_23n I1_I1298_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I122_XP_MP0 (VDD I1_I1298_P26_25 I1_I1298_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I25_MP1 (I1_I1298_gn25 I1_b16_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I25_MP0 (VDD I1_p15_24 I1_I1298_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1298_I24_MP1 (I1_I1298_gn24 I1_b16_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1298_I24_MP0 (VDD I1_p15_23 I1_I1298_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I179_XP_MP1 (I1_I1252_P28_13n I1_I1252_P20_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I179_XP_MP0 (VDD I1_I1252_P28_21 I1_I1252_P28_13n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I122_XP_MP1 (I1_I1252_P26_23n I1_I1252_P24_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I122_XP_MP0 (VDD I1_I1252_P26_25 I1_I1252_P26_23n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I182_XP_MP1 (I1_I1252_P31_16n I1_I1252_P23_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I182_XP_MP0 (VDD I1_I1252_P31_24 I1_I1252_P31_16n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I123_XP_MP1 (I1_I1252_P27_24n I1_I1252_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I123_XP_MP0 (VDD I1_I1252_P27_26 I1_I1252_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I23_MP1 (I1_I1252_gn23 I1_b15_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I23_MP0 (VDD I1_p14_22 I1_I1252_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I24_MP1 (I1_I1252_gn24 I1_b15_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I24_MP0 (VDD I1_p14_23 I1_I1252_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1252_I25_MP1 (I1_I1252_gn25 I1_b15_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1252_I25_MP0 (VDD I1_p14_24 I1_I1252_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I31_MP1 (I1_I1206_gn31 I1_b14_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I31_MP0 (VDD I1_p13_30 I1_I1206_gn31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I30_MP1 (I1_I1206_gn30 I1_b14_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I30_MP0 (VDD I1_p13_29 I1_I1206_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I24_MP1 (I1_I1206_gn24 I1_b14_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I24_MP0 (VDD I1_p13_23 I1_I1206_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I123_XP_MP1 (I1_I1206_P27_24n I1_I1206_P25_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I123_XP_MP0 (VDD I1_I1206_P27_26 I1_I1206_P27_24n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I125_XP_MP1 (I1_I1206_P29_26n I1_I1206_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I125_XP_MP0 (VDD I1_I1206_P29_28 I1_I1206_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I25_MP1 (I1_I1206_gn25 I1_b14_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I25_MP0 (VDD I1_p13_24 I1_I1206_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I26_MP1 (I1_I1206_gn26 I1_b14_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I26_MP0 (VDD I1_p13_25 I1_I1206_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I1206_I124_XP_MP1 (I1_I1206_P28_25n I1_I1206_P26_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I1206_I124_XP_MP0 (VDD I1_I1206_P28_27 I1_I1206_P28_25n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I27_MP1 (I1_I838_gn27 I1_b6_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I27_MP0 (VDD I1_p5_26 I1_I838_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I26_MP1 (I1_I838_gn26 I1_b6_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I26_MP0 (VDD I1_p5_25 I1_I838_gn26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I24_MP1 (I1_I838_gn24 I1_b6_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I24_MP0 (VDD I1_p5_23 I1_I838_gn24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
    I_MXI1_I838_I23_MP1 (I1_I838_gn23 I1_b6_23 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.05276p as=0.08156p pd=0.67999u ps=1.15999u
    I_MXI1_I838_I23_MP0 (VDD I1_p5_22 I1_I838_gn23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.08156p as=0.05276p pd=1.15999u ps=0.67999u
