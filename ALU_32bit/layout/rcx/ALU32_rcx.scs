    I_MXI0_I379_MP2 (I0_B_11_b3_3 I0_B_11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I379_MP2_1 (VDD I0_B_11_b2_1 I0_B_11_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I381_MP2 (I0_B_11_b3_5 I0_B_11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I381_MP2_1 (VDD I0_B_11_b2_1 I0_B_11_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I196_MP2 (I0_A_18_b3_2 I0_A_18_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I196_MP2_1 (VDD I0_A_18_b2_0 I0_A_18_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I380_MP2 (I0_B_11_b3_4 I0_B_11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I380_MP2_1 (VDD I0_B_11_b2_1 I0_B_11_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I206_MP2 (I0_A_19_b3_2 I0_A_19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I206_MP2_1 (VDD I0_A_19_b2_0 I0_A_19_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I820_MP2 (I0_one6_b3_3 I0_one6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I820_MP2_1 (VDD I0_one6_b2_1 I0_one6_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I711_MP2 (I0_one4_b3_4 I0_one4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I711_MP2_1 (VDD I0_one4_b2_1 I0_one4_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I173_MP2 (I0_A_16_b2_1 I0_A_16_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I173_MP2_1 (VDD I0_A_16_b1_0 I0_A_16_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I766_MP2 (I0_one5_b3_4 I0_one5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I766_MP2_1 (VDD I0_one5_b2_1 I0_one5_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I776_MP2 (I0_two5_b3_4 I0_two5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I776_MP2_1 (VDD I0_two5_b2_1 I0_two5_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I777_MP2 (I0_two5_b3_5 I0_two5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I777_MP2_1 (VDD I0_two5_b2_1 I0_two5_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I767_MP2 (I0_one5_b3_5 I0_one5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I767_MP2_1 (VDD I0_one5_b2_1 I0_one5_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I326_MP2 (I0_A_31_b3_2 I0_A_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I326_MP2_1 (VDD I0_A_31_b2_0 I0_A_31_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1724_MP2 (I1_qu6_b3_4 I1_qu6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1724_MP2_1 (VDD I1_qu6_b2_1 I1_qu6_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1725_MP2 (I1_qu6_b3_5 I1_qu6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1725_MP2_1 (VDD I1_qu6_b2_1 I1_qu6_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1723_MP2 (I1_qu6_b3_3 I1_qu6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1723_MP2_1 (VDD I1_qu6_b2_1 I1_qu6_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1719_MP2 (I1_qu6_b2_1 I1_qu6_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1719_MP2_1 (VDD I1_qu6_b1_0 I1_qu6_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1715_MP2 (I1_qu6 I1_p25_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1715_MP2_1 (VDD I1_p25_32 I1_qu6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1717_MP2 (I1_qu6_b1_0 I1_qu6_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1717_MP2_1 (VDD I1_qu6_b0 I1_qu6_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1722_MP2 (I1_qu6_b3_2 I1_qu6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1722_MP2_1 (VDD I1_qu6_b2_0 I1_qu6_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1718_MP2 (I1_qu6_b2_0 I1_qu6_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1718_MP2_1 (VDD I1_qu6_b1_0 I1_qu6_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I307_MP2 (I1_dd14_b3_4 I1_dd14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I307_MP2_1 (VDD I1_dd14_b2_1 I1_dd14_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I294_MP2 (I1_dd13_b3_4 I1_dd13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I294_MP2_1 (VDD I1_dd13_b2_1 I1_dd13_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I27_MP2 (I1_B_0_b1_0 I1_B_0_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I27_MP2_1 (VDD I1_B_0_b0 I1_B_0_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I4_MP2 (I2_I1_SUB_b3_0 I2_I1_SUB_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I4_MP2_1 (VDD I2_I1_SUB_b2_0 I2_I1_SUB_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I494_MP2 (I0_two0_b1_0 I0_two0_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I494_MP2_1 (VDD I0_two0_b0 I0_two0_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I363_MP2 (I0_B_9_b1_0 I0_B_9_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I363_MP2_1 (VDD I0_B_9_b0 I0_B_9_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I495_MP2 (I0_two0_b2_0 I0_two0_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I495_MP2_1 (VDD I0_two0_b1_0 I0_two0_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I499_MP2 (I0_two0_b3_2 I0_two0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I499_MP2_1 (VDD I0_two0_b2_0 I0_two0_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I485_MP2 (I0_one0_b2_0 I0_one0_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I485_MP2_1 (VDD I0_one0_b1_0 I0_one0_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I489_MP2 (I0_one0_b3_2 I0_one0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I489_MP2_1 (VDD I0_one0_b2_0 I0_one0_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I337_MP2 (I0_B_3_b3_1 I0_B_3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I337_MP2_1 (VDD I0_B_3_b2_0 I0_B_3_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I714_MP2 (I0_two4_b1_0 I0_two4_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I714_MP2_1 (VDD I0_two4_b0 I0_two4_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I364_MP2 (I0_B_9_b2_0 I0_B_9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I364_MP2_1 (VDD I0_B_9_b1_0 I0_B_9_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I144_MP2 (I0_A_13_b3_0 I0_A_13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I144_MP2_1 (VDD I0_A_13_b2_0 I0_A_13_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I654_MP2 (I0_one3_b3_2 I0_one3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I654_MP2_1 (VDD I0_one3_b2_0 I0_one3_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I374_MP2 (I0_B_11_b2_0 I0_B_11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I374_MP2_1 (VDD I0_B_11_b1_0 I0_B_11_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I134_MP2 (I0_A_12_b3_0 I0_A_12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I134_MP2_1 (VDD I0_A_12_b2_0 I0_A_12_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I760_MP2 (I0_one5_b2_0 I0_one5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I760_MP2_1 (VDD I0_one5_b1_0 I0_one5_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I164_MP2 (I0_A_15_b3_0 I0_A_15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I164_MP2_1 (VDD I0_A_15_b2_0 I0_A_15_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I122_MP2 (I0_A_11_b2_0 I0_A_11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I122_MP2_1 (VDD I0_A_11_b1_0 I0_A_11_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I154_MP2 (I0_A_14_b3_0 I0_A_14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I154_MP2_1 (VDD I0_A_14_b2_0 I0_A_14_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I126_MP2 (I0_A_11_b3_2 I0_A_11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I126_MP2_1 (VDD I0_A_11_b2_0 I0_A_11_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I125_MP2 (I0_A_11_b3_1 I0_A_11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I125_MP2_1 (VDD I0_A_11_b2_0 I0_A_11_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I162_MP2 (I0_A_15_b2_0 I0_A_15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I162_MP2_1 (VDD I0_A_15_b1_0 I0_A_15_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I136_MP2 (I0_A_12_b3_2 I0_A_12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I136_MP2_1 (VDD I0_A_12_b2_0 I0_A_12_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I152_MP2 (I0_A_14_b2_0 I0_A_14_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I152_MP2_1 (VDD I0_A_14_b1_0 I0_A_14_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I146_MP2 (I0_A_13_b3_2 I0_A_13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I146_MP2_1 (VDD I0_A_13_b2_0 I0_A_13_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I145_MP2 (I0_A_13_b3_1 I0_A_13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I145_MP2_1 (VDD I0_A_13_b2_0 I0_A_13_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I155_MP2 (I0_A_14_b3_1 I0_A_14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I155_MP2_1 (VDD I0_A_14_b2_0 I0_A_14_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I825_MP2 (I0_two6_b2_0 I0_two6_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I825_MP2_1 (VDD I0_two6_b1_0 I0_two6_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I166_MP2 (I0_A_15_b3_2 I0_A_15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I166_MP2_1 (VDD I0_A_15_b2_0 I0_A_15_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I165_MP2 (I0_A_15_b3_1 I0_A_15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I165_MP2_1 (VDD I0_A_15_b2_0 I0_A_15_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I156_MP2 (I0_A_14_b3_2 I0_A_14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I156_MP2_1 (VDD I0_A_14_b2_0 I0_A_14_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I706_MP2 (I0_one4_b2_1 I0_one4_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I706_MP2_1 (VDD I0_one4_b1_0 I0_one4_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I879_MP2 (I0_two7_b1_0 I0_two7_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I879_MP2_1 (VDD I0_two7_b0 I0_two7_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I771_MP2 (I0_two5_b2_1 I0_two5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I771_MP2_1 (VDD I0_two5_b1_0 I0_two5_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I826_MP2 (I0_two6_b2_1 I0_two6_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I826_MP2_1 (VDD I0_two6_b1_0 I0_two6_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I385_MP2 (I0_B_13_b2_1 I0_B_13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I385_MP2_1 (VDD I0_B_13_b1_0 I0_B_13_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I143_MP2 (I0_A_13_b2_1 I0_A_13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I143_MP2_1 (VDD I0_A_13_b1_0 I0_A_13_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I816_MP2 (I0_one6_b2_1 I0_one6_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I816_MP2_1 (VDD I0_one6_b1_0 I0_one6_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I830_MP2 (I0_two6_b3_3 I0_two6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I830_MP2_1 (VDD I0_two6_b2_1 I0_two6_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I885_MP2 (I0_two7_b3_3 I0_two7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I885_MP2_1 (VDD I0_two7_b2_1 I0_two7_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I390_MP2 (I0_B_13_b3_4 I0_B_13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I390_MP2_1 (VDD I0_B_13_b2_1 I0_B_13_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I831_MP2 (I0_two6_b3_4 I0_two6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I831_MP2_1 (VDD I0_two6_b2_1 I0_two6_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I832_MP2 (I0_two6_b3_5 I0_two6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I832_MP2_1 (VDD I0_two6_b2_1 I0_two6_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I821_MP2 (I0_one6_b3_4 I0_one6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I821_MP2_1 (VDD I0_one6_b2_1 I0_one6_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I822_MP2 (I0_one6_b3_5 I0_one6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I822_MP2_1 (VDD I0_one6_b2_1 I0_one6_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I327_MP2 (I0_A_31_b3_3 I0_A_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I327_MP2_1 (VDD I0_A_31_b2_0 I0_A_31_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1671_MP2 (I1_qu7_b1_0 I1_qu7_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1671_MP2_1 (VDD I1_qu7_b0 I1_qu7_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I320_MP2 (I1_dd15_b3_4 I1_dd15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I320_MP2_1 (VDD I1_dd15_b2_1 I1_dd15_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I346_MP2 (I1_dd17_b3_4 I1_dd17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I346_MP2_1 (VDD I1_dd17_b2_1 I1_dd17_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I333_MP2 (I1_dd16_b3_4 I1_dd16_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I333_MP2_1 (VDD I1_dd16_b2_1 I1_dd16_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I281_MP2 (I1_dd12_b3_4 I1_dd12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I281_MP2_1 (VDD I1_dd12_b2_1 I1_dd12_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I5_MP2 (I2_I3_SEL_AND_b3_1 I2_I3_SEL_AND_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I5_MP2_1 (VDD I2_I3_SEL_AND_b2_0 I2_I3_SEL_AND_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I15_MP2 (I2_I3_SEL_OR_b3_1 I2_I3_SEL_OR_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I15_MP2_1 (VDD I2_I3_SEL_OR_b2_0 I2_I3_SEL_OR_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I4_MP2 (I0_B_1_b3_0 I0_B_1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I4_MP2_1 (VDD I0_B_1_b2_0 I0_B_1_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I552_MP2 (I0_two1_b3_0 I0_two1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I552_MP2_1 (VDD I0_two1_b2_0 I0_two1_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I553_MP2 (I0_two1_b3_1 I0_two1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I553_MP2_1 (VDD I0_two1_b2_0 I0_two1_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I543_MP2 (I0_one1_b3_1 I0_one1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I543_MP2_1 (VDD I0_one1_b2_0 I0_one1_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I607_MP2 (I0_two2_b3_0 I0_two2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I607_MP2_1 (VDD I0_two2_b2_0 I0_two2_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I597_MP2 (I0_one2_b3_0 I0_one2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I597_MP2_1 (VDD I0_one2_b2_0 I0_one2_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I608_MP2 (I0_two2_b3_1 I0_two2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I608_MP2_1 (VDD I0_two2_b2_0 I0_two2_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I598_MP2 (I0_one2_b3_1 I0_one2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I598_MP2_1 (VDD I0_one2_b2_0 I0_one2_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I705_MP2 (I0_one4_b2_0 I0_one4_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I705_MP2_1 (VDD I0_one4_b1_0 I0_one4_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I376_MP2 (I0_B_11_b3_0 I0_B_11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I376_MP2_1 (VDD I0_B_11_b2_0 I0_B_11_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I715_MP2 (I0_two4_b2_0 I0_two4_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I715_MP2_1 (VDD I0_two4_b1_0 I0_two4_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I719_MP2 (I0_two4_b3_2 I0_two4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I719_MP2_1 (VDD I0_two4_b2_0 I0_two4_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I764_MP2 (I0_one5_b3_2 I0_one5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I764_MP2_1 (VDD I0_one5_b2_0 I0_one5_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I774_MP2 (I0_two5_b3_2 I0_two5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I774_MP2_1 (VDD I0_two5_b2_0 I0_two5_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I819_MP2 (I0_one6_b3_2 I0_one6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I819_MP2_1 (VDD I0_one6_b2_0 I0_one6_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I388_MP2 (I0_B_13_b3_2 I0_B_13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I388_MP2_1 (VDD I0_B_13_b2_0 I0_B_13_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I123_MP2 (I0_A_11_b2_1 I0_A_11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I123_MP2_1 (VDD I0_A_11_b1_0 I0_A_11_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I829_MP2 (I0_two6_b3_2 I0_two6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I829_MP2_1 (VDD I0_two6_b2_0 I0_two6_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I869_MP2 (I0_one7_b1_0 I0_one7_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I869_MP2_1 (VDD I0_one7_b0 I0_one7_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1721_MP2 (I1_qu6_b3_1 I1_qu6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1721_MP2_1 (VDD I1_qu6_b2_0 I1_qu6_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1626_MP2 (I1_qu8_b2_0 I1_qu8_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1626_MP2_1 (VDD I1_qu8_b1_0 I1_qu8_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1630_MP2 (I1_qu8_b3_2 I1_qu8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1630_MP2_1 (VDD I1_qu8_b2_0 I1_qu8_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1625_MP2 (I1_qu8_b1_0 I1_qu8_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1625_MP2_1 (VDD I1_qu8_b0 I1_qu8_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1623_MP2 (I1_qu8 I1_p23_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1623_MP2_1 (VDD I1_p23_32 I1_qu8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I497_MP2 (I0_two0_b3_0 I0_two0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I497_MP2_1 (VDD I0_two0_b2_0 I0_two0_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I366_MP2 (I0_B_9_b3_0 I0_B_9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I366_MP2_1 (VDD I0_B_9_b2_0 I0_B_9_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I104_MP2 (I0_A_9_b3_0 I0_A_9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I104_MP2_1 (VDD I0_A_9_b2_0 I0_A_9_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I111_MP2 (I0_A_10_b1_0 I0_A_10_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I111_MP2_1 (VDD I0_A_10_b0 I0_A_10_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I652_MP2 (I0_one3_b3_0 I0_one3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I652_MP2_1 (VDD I0_one3_b2_0 I0_one3_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I114_MP2 (I0_A_10_b3_0 I0_A_10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I114_MP2_1 (VDD I0_A_10_b2_0 I0_A_10_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I653_MP2 (I0_one3_b3_1 I0_one3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I653_MP2_1 (VDD I0_one3_b2_0 I0_one3_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I663_MP2 (I0_two3_b3_1 I0_two3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I663_MP2_1 (VDD I0_two3_b2_0 I0_two3_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I115_MP2 (I0_A_10_b3_1 I0_A_10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I115_MP2_1 (VDD I0_A_10_b2_0 I0_A_10_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I709_MP2 (I0_one4_b3_2 I0_one4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I709_MP2_1 (VDD I0_one4_b2_0 I0_one4_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I105_MP2 (I0_A_9_b3_1 I0_A_9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I105_MP2_1 (VDD I0_A_9_b2_0 I0_A_9_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I106_MP2 (I0_A_9_b3_2 I0_A_9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I106_MP2_1 (VDD I0_A_9_b2_0 I0_A_9_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I368_MP2 (I0_B_9_b3_2 I0_B_9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I368_MP2_1 (VDD I0_B_9_b2_0 I0_B_9_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I378_MP2 (I0_B_11_b3_2 I0_B_11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I378_MP2_1 (VDD I0_B_11_b2_0 I0_B_11_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I377_MP2 (I0_B_11_b3_1 I0_B_11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I377_MP2_1 (VDD I0_B_11_b2_0 I0_B_11_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I116_MP2 (I0_A_10_b3_2 I0_A_10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I116_MP2_1 (VDD I0_A_10_b2_0 I0_A_10_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I112_MP2 (I0_A_10_b2_0 I0_A_10_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I112_MP2_1 (VDD I0_A_10_b1_0 I0_A_10_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I828_MP2 (I0_two6_b3_1 I0_two6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I828_MP2_1 (VDD I0_two6_b2_0 I0_two6_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I387_MP2 (I0_B_13_b3_1 I0_B_13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I387_MP2_1 (VDD I0_B_13_b2_0 I0_B_13_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I394_MP2 (I0_B_15_b2_0 I0_B_15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I394_MP2_1 (VDD I0_B_15_b1_0 I0_B_15_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I398_MP2 (I0_B_15_b3_2 I0_B_15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I398_MP2_1 (VDD I0_B_15_b2_0 I0_B_15_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I870_MP2 (I0_one7_b2_0 I0_one7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I870_MP2_1 (VDD I0_one7_b1_0 I0_one7_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I874_MP2 (I0_one7_b3_2 I0_one7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I874_MP2_1 (VDD I0_one7_b2_0 I0_one7_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I153_MP2 (I0_A_14_b2_1 I0_A_14_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I153_MP2_1 (VDD I0_A_14_b1_0 I0_A_14_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I133_MP2 (I0_A_12_b2_1 I0_A_12_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I133_MP2_1 (VDD I0_A_12_b1_0 I0_A_12_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I163_MP2 (I0_A_15_b2_1 I0_A_15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I163_MP2_1 (VDD I0_A_15_b1_0 I0_A_15_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I881_MP2 (I0_two7_b2_1 I0_two7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I881_MP2_1 (VDD I0_two7_b1_0 I0_two7_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I875_MP2 (I0_one7_b3_3 I0_one7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I875_MP2_1 (VDD I0_one7_b2_1 I0_one7_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I871_MP2 (I0_one7_b2_1 I0_one7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I871_MP2_1 (VDD I0_one7_b1_0 I0_one7_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I395_MP2 (I0_B_15_b2_1 I0_B_15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I395_MP2_1 (VDD I0_B_15_b1_0 I0_B_15_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I399_MP2 (I0_B_15_b3_3 I0_B_15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I399_MP2_1 (VDD I0_B_15_b2_1 I0_B_15_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I401_MP2 (I0_B_15_b3_5 I0_B_15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I401_MP2_1 (VDD I0_B_15_b2_1 I0_B_15_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I400_MP2 (I0_B_15_b3_4 I0_B_15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I400_MP2_1 (VDD I0_B_15_b2_1 I0_B_15_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I886_MP2 (I0_two7_b3_4 I0_two7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I886_MP2_1 (VDD I0_two7_b2_1 I0_two7_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I876_MP2 (I0_one7_b3_4 I0_one7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I876_MP2_1 (VDD I0_one7_b2_1 I0_one7_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I94_MP2 (I0_A_8_b3_0 I0_A_8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I94_MP2_1 (VDD I0_A_8_b2_0 I0_A_8_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I84_MP2 (I0_A_7_b3_0 I0_A_7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I84_MP2_1 (VDD I0_A_7_b2_0 I0_A_7_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I74_MP2 (I0_A_6_b3_0 I0_A_6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I74_MP2_1 (VDD I0_A_6_b2_0 I0_A_6_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I92_MP2 (I0_A_8_b2_0 I0_A_8_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I92_MP2_1 (VDD I0_A_8_b1_0 I0_A_8_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I102_MP2 (I0_A_9_b2_0 I0_A_9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I102_MP2_1 (VDD I0_A_9_b1_0 I0_A_9_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I662_MP2 (I0_two3_b3_0 I0_two3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I662_MP2_1 (VDD I0_two3_b2_0 I0_two3_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I367_MP2 (I0_B_9_b3_1 I0_B_9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I367_MP2_1 (VDD I0_B_9_b2_0 I0_B_9_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I96_MP2 (I0_A_8_b3_2 I0_A_8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I96_MP2_1 (VDD I0_A_8_b2_0 I0_A_8_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I95_MP2 (I0_A_8_b3_1 I0_A_8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I95_MP2_1 (VDD I0_A_8_b2_0 I0_A_8_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I763_MP2 (I0_one5_b3_1 I0_one5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I763_MP2_1 (VDD I0_one5_b2_0 I0_one5_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I827_MP2 (I0_two6_b3_0 I0_two6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I827_MP2_1 (VDD I0_two6_b2_0 I0_two6_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I817_MP2 (I0_one6_b3_0 I0_one6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I817_MP2_1 (VDD I0_one6_b2_0 I0_one6_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I818_MP2 (I0_one6_b3_1 I0_one6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I818_MP2_1 (VDD I0_one6_b2_0 I0_one6_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I397_MP2 (I0_B_15_b3_1 I0_B_15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I397_MP2_1 (VDD I0_B_15_b2_0 I0_B_15_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I396_MP2 (I0_B_15_b3_0 I0_B_15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I396_MP2_1 (VDD I0_B_15_b2_0 I0_B_15_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I877_MP2 (I0_one7_b3_5 I0_one7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I877_MP2_1 (VDD I0_one7_b2_1 I0_one7_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I887_MP2 (I0_two7_b3_5 I0_two7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I887_MP2_1 (VDD I0_two7_b2_1 I0_two7_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I77_MP2 (I2_I3_SEL_AS_b3_1 I2_I3_SEL_AS_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I77_MP2_1 (VDD I2_I3_SEL_AS_b2_0 I2_I3_SEL_AS_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I487_MP2 (I0_one0_b3_0 I0_one0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I487_MP2_1 (VDD I0_one0_b2_0 I0_one0_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I64_MP2 (I0_A_5_b3_0 I0_A_5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I64_MP2_1 (VDD I0_A_5_b2_0 I0_A_5_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I82_MP2 (I0_A_7_b2_0 I0_A_7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I82_MP2_1 (VDD I0_A_7_b1_0 I0_A_7_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I717_MP2 (I0_two4_b3_0 I0_two4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I717_MP2_1 (VDD I0_two4_b2_0 I0_two4_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I75_MP2 (I0_A_6_b3_1 I0_A_6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I75_MP2_1 (VDD I0_A_6_b2_0 I0_A_6_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I707_MP2 (I0_one4_b3_0 I0_one4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I707_MP2_1 (VDD I0_one4_b2_0 I0_one4_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I86_MP2 (I0_A_7_b3_2 I0_A_7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I86_MP2_1 (VDD I0_A_7_b2_0 I0_A_7_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I718_MP2 (I0_two4_b3_1 I0_two4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I718_MP2_1 (VDD I0_two4_b2_0 I0_two4_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I773_MP2 (I0_two5_b3_1 I0_two5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I773_MP2_1 (VDD I0_two5_b2_0 I0_two5_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I882_MP2 (I0_two7_b3_0 I0_two7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I882_MP2_1 (VDD I0_two7_b2_0 I0_two7_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I873_MP2 (I0_one7_b3_1 I0_one7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I873_MP2_1 (VDD I0_one7_b2_0 I0_one7_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I113_MP2 (I0_A_10_b2_1 I0_A_10_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I113_MP2_1 (VDD I0_A_10_b1_0 I0_A_10_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I359_MP2 (I1_dd18_b3_4 I1_dd18_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I359_MP2_1 (VDD I1_dd18_b2_1 I1_dd18_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I372_MP2 (I1_dd19_b3_4 I1_dd19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I372_MP2_1 (VDD I1_dd19_b2_1 I1_dd19_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2073_MP2 (I1_sq_b3_1 I1_sq_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2073_MP2_1 (VDD I1_sq_b2_0 I1_sq_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I65_MP2 (I0_A_5_b3_1 I0_A_5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I65_MP2_1 (VDD I0_A_5_b2_0 I0_A_5_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I72_MP2 (I0_A_6_b2_0 I0_A_6_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I72_MP2_1 (VDD I0_A_6_b1_0 I0_A_6_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I83_MP2 (I0_A_7_b2_1 I0_A_7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I83_MP2_1 (VDD I0_A_7_b1_0 I0_A_7_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I76_MP2 (I0_A_6_b3_2 I0_A_6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I76_MP2_1 (VDD I0_A_6_b2_0 I0_A_6_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I66_MP2 (I0_A_5_b3_2 I0_A_5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I66_MP2_1 (VDD I0_A_5_b2_0 I0_A_5_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I772_MP2 (I0_two5_b3_0 I0_two5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I772_MP2_1 (VDD I0_two5_b2_0 I0_two5_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I883_MP2 (I0_two7_b3_1 I0_two7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I883_MP2_1 (VDD I0_two7_b2_0 I0_two7_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I872_MP2 (I0_one7_b3_0 I0_one7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I872_MP2_1 (VDD I0_one7_b2_0 I0_one7_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I203_MP2 (I0_A_19_b2_1 I0_A_19_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I203_MP2_1 (VDD I0_A_19_b1_0 I0_A_19_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I213_MP2 (I0_A_20_b2_1 I0_A_20_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I213_MP2_1 (VDD I0_A_20_b1_0 I0_A_20_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1768_MP2 (I1_qu5_b3_2 I1_qu5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1768_MP2_1 (VDD I1_qu5_b2_0 I1_qu5_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1767_MP2 (I1_qu5_b3_1 I1_qu5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1767_MP2_1 (VDD I1_qu5_b2_0 I1_qu5_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1720_MP2 (I1_qu6_b3_0 I1_qu6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1720_MP2_1 (VDD I1_qu6_b2_0 I1_qu6_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1669_MP2 (I1_qu7 I1_p24_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1669_MP2_1 (VDD I1_p24_32 I1_qu7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I385_MP2 (I1_dd20_b3_4 I1_dd20_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I385_MP2_1 (VDD I1_dd20_b2_1 I1_dd20_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I34_MP2 (I2_I3_SEL_NOT_b3_0 I2_I3_SEL_NOT_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I34_MP2_1 (VDD I2_I3_SEL_NOT_b2_0 I2_I3_SEL_NOT_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I4_MP2 (I2_I3_SEL_AND_b3_0 I2_I3_SEL_AND_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I4_MP2_1 (VDD I2_I3_SEL_AND_b2_0 I2_I3_SEL_AND_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I101_MP2 (I0_A_9_b1_0 I0_A_9_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I101_MP2_1 (VDD I0_A_9_b0 I0_A_9_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I71_MP2 (I0_A_6_b1_0 I0_A_6_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I71_MP2_1 (VDD I0_A_6_b0 I0_A_6_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I81_MP2 (I0_A_7_b1_0 I0_A_7_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I81_MP2_1 (VDD I0_A_7_b0 I0_A_7_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I91_MP2 (I0_A_8_b1_0 I0_A_8_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I91_MP2_1 (VDD I0_A_8_b0 I0_A_8_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I55_MP2 (I0_A_4_b3_1 I0_A_4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I55_MP2_1 (VDD I0_A_4_b2_0 I0_A_4_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I762_MP2 (I0_one5_b3_0 I0_one5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I762_MP2_1 (VDD I0_one5_b2_0 I0_one5_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1761_MP2 (I1_qu5 I1_p26_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1761_MP2_1 (VDD I1_p26_32 I1_qu5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1581_MP2 (I1_qu9_b2_1 I1_qu9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1581_MP2_1 (VDD I1_qu9_b1_0 I1_qu9_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1585_MP2 (I1_qu9_b3_3 I1_qu9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1585_MP2_1 (VDD I1_qu9_b2_1 I1_qu9_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I14_MP2 (I2_I3_SEL_OR_b3_0 I2_I3_SEL_OR_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I14_MP2_1 (VDD I2_I3_SEL_OR_b2_0 I2_I3_SEL_OR_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I24_MP2 (I2_I3_SEL_XOR_b3_0 I2_I3_SEL_XOR_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I24_MP2_1 (VDD I2_I3_SEL_XOR_b2_0 I2_I3_SEL_XOR_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I54_MP2 (I0_A_4_b3_0 I0_A_4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I54_MP2_1 (VDD I0_A_4_b2_0 I0_A_4_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I46_MP2 (I0_A_3_b3_2 I0_A_3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I46_MP2_1 (VDD I0_A_3_b2_0 I0_A_3_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I45_MP2 (I0_A_3_b3_1 I0_A_3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I45_MP2_1 (VDD I0_A_3_b2_0 I0_A_3_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I56_MP2 (I0_A_4_b3_2 I0_A_4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I56_MP2_1 (VDD I0_A_4_b2_0 I0_A_4_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I103_MP2 (I0_A_9_b2_1 I0_A_9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I103_MP2_1 (VDD I0_A_9_b1_0 I0_A_9_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I73_MP2 (I0_A_6_b2_1 I0_A_6_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I73_MP2_1 (VDD I0_A_6_b1_0 I0_A_6_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I167_MP2 (I0_A_15_b3_3 I0_A_15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I167_MP2_1 (VDD I0_A_15_b2_1 I0_A_15_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I193_MP2 (I0_A_18_b2_1 I0_A_18_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I193_MP2_1 (VDD I0_A_18_b1_0 I0_A_18_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I183_MP2 (I0_A_17_b2_1 I0_A_17_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I183_MP2_1 (VDD I0_A_17_b1_0 I0_A_17_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1631_MP2 (I1_qu8_b3_3 I1_qu8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1631_MP2_1 (VDD I1_qu8_b2_1 I1_qu8_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I398_MP2 (I1_dd21_b3_4 I1_dd21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I398_MP2_1 (VDD I1_dd21_b2_1 I1_dd21_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1627_MP2 (I1_qu8_b2_1 I1_qu8_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1627_MP2_1 (VDD I1_qu8_b1_0 I1_qu8_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I76_MP2 (I2_I3_SEL_AS_b3_0 I2_I3_SEL_AS_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I76_MP2_1 (VDD I2_I3_SEL_AS_b2_0 I2_I3_SEL_AS_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I34_MP2 (I0_A_2_b3_0 I0_A_2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I34_MP2_1 (VDD I0_A_2_b2_0 I0_A_2_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I32_MP2 (I0_A_2_b2_0 I0_A_2_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I32_MP2_1 (VDD I0_A_2_b1_0 I0_A_2_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I44_MP2 (I0_A_3_b3_0 I0_A_3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I44_MP2_1 (VDD I0_A_3_b2_0 I0_A_3_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I52_MP2 (I0_A_4_b2_0 I0_A_4_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I52_MP2_1 (VDD I0_A_4_b1_0 I0_A_4_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I16_MP2 (I0_A_0_b3_2 I0_A_0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I16_MP2_1 (VDD I0_A_0_b2_0 I0_A_0_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I15_MP2 (I0_A_0_b3_1 I0_A_0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I15_MP2_1 (VDD I0_A_0_b2_0 I0_A_0_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I25_MP2 (I0_A_1_b3_1 I0_A_1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I25_MP2_1 (VDD I0_A_1_b2_0 I0_A_1_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I26_MP2 (I0_A_1_b3_2 I0_A_1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I26_MP2_1 (VDD I0_A_1_b2_0 I0_A_1_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I62_MP2 (I0_A_5_b2_0 I0_A_5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I62_MP2_1 (VDD I0_A_5_b1_0 I0_A_5_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I36_MP2 (I0_A_2_b3_2 I0_A_2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I36_MP2_1 (VDD I0_A_2_b2_0 I0_A_2_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I35_MP2 (I0_A_2_b3_1 I0_A_2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I35_MP2_1 (VDD I0_A_2_b2_0 I0_A_2_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I117_MP2 (I0_A_10_b3_3 I0_A_10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I117_MP2_1 (VDD I0_A_10_b2_1 I0_A_10_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I147_MP2 (I0_A_13_b3_3 I0_A_13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I147_MP2_1 (VDD I0_A_13_b2_1 I0_A_13_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I197_MP2 (I0_A_18_b3_3 I0_A_18_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I197_MP2_1 (VDD I0_A_18_b2_1 I0_A_18_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I157_MP2 (I0_A_14_b3_3 I0_A_14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I157_MP2_1 (VDD I0_A_14_b2_1 I0_A_14_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I187_MP2 (I0_A_17_b3_3 I0_A_17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I187_MP2_1 (VDD I0_A_17_b2_1 I0_A_17_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I207_MP2 (I0_A_19_b3_3 I0_A_19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I207_MP2_1 (VDD I0_A_19_b2_1 I0_A_19_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1763_MP2 (I1_qu5_b1_0 I1_qu5_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1763_MP2_1 (VDD I1_qu5_b0 I1_qu5_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1765_MP2 (I1_qu5_b2_1 I1_qu5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1765_MP2_1 (VDD I1_qu5_b1_0 I1_qu5_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1764_MP2 (I1_qu5_b2_0 I1_qu5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1764_MP2_1 (VDD I1_qu5_b1_0 I1_qu5_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1632_MP2 (I1_qu8_b3_4 I1_qu8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1632_MP2_1 (VDD I1_qu8_b2_1 I1_qu8_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1633_MP2 (I1_qu8_b3_5 I1_qu8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1633_MP2_1 (VDD I1_qu8_b2_1 I1_qu8_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I424_MP2 (I1_dd23_b3_4 I1_dd23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I424_MP2_1 (VDD I1_dd23_b2_1 I1_dd23_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I515_MP2 (I1_dd30_b3_4 I1_dd30_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I515_MP2_1 (VDD I1_dd30_b2_1 I1_dd30_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1587_MP2 (I1_qu9_b3_5 I1_qu9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1587_MP2_1 (VDD I1_qu9_b2_1 I1_qu9_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2072_MP2 (I1_sq_b3_0 I1_sq_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2072_MP2_1 (VDD I1_sq_b2_0 I1_sq_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I61_MP2 (I0_A_5_b1_0 I0_A_5_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I61_MP2_1 (VDD I0_A_5_b0 I0_A_5_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I24_MP2 (I0_A_1_b3_0 I0_A_1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I24_MP2_1 (VDD I0_A_1_b2_0 I0_A_1_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I14_MP2 (I0_A_0_b3_0 I0_A_0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I14_MP2_1 (VDD I0_A_0_b2_0 I0_A_0_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I22_MP2 (I0_A_1_b2_0 I0_A_1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I22_MP2_1 (VDD I0_A_1_b1_0 I0_A_1_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I93_MP2 (I0_A_8_b2_1 I0_A_8_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I93_MP2_1 (VDD I0_A_8_b1_0 I0_A_8_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I927_MP2 (I0_one8_b3_0 I0_one8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I927_MP2_1 (VDD I0_one8_b2_0 I0_one8_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I97_MP2 (I0_A_8_b3_3 I0_A_8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I97_MP2_1 (VDD I0_A_8_b2_1 I0_A_8_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I928_MP2 (I0_one8_b3_1 I0_one8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I928_MP2_1 (VDD I0_one8_b2_0 I0_one8_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I938_MP2 (I0_two8_b3_1 I0_two8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I938_MP2_1 (VDD I0_two8_b2_0 I0_two8_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I107_MP2 (I0_A_9_b3_3 I0_A_9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I107_MP2_1 (VDD I0_A_9_b2_1 I0_A_9_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I939_MP2 (I0_two8_b3_2 I0_two8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I939_MP2_1 (VDD I0_two8_b2_0 I0_two8_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I929_MP2 (I0_one8_b3_2 I0_one8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I929_MP2_1 (VDD I0_one8_b2_0 I0_one8_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I925_MP2 (I0_one8_b2_0 I0_one8_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I925_MP2_1 (VDD I0_one8_b1_0 I0_one8_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I408_MP2 (I0_B_17_b3_2 I0_B_17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I408_MP2_1 (VDD I0_B_17_b2_0 I0_B_17_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I127_MP2 (I0_A_11_b3_3 I0_A_11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I127_MP2_1 (VDD I0_A_11_b2_1 I0_A_11_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I137_MP2 (I0_A_12_b3_3 I0_A_12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I137_MP2_1 (VDD I0_A_12_b2_1 I0_A_12_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I418_MP2 (I0_B_19_b3_2 I0_B_19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I418_MP2_1 (VDD I0_B_19_b2_0 I0_B_19_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I404_MP2 (I0_B_17_b2_0 I0_B_17_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I404_MP2_1 (VDD I0_B_17_b1_0 I0_B_17_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I217_MP2 (I0_A_20_b3_3 I0_A_20_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I217_MP2_1 (VDD I0_A_20_b2_1 I0_A_20_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1770_MP2 (I1_qu5_b3_4 I1_qu5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1770_MP2_1 (VDD I1_qu5_b2_1 I1_qu5_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1771_MP2 (I1_qu5_b3_5 I1_qu5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1771_MP2_1 (VDD I1_qu5_b2_1 I1_qu5_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1769_MP2 (I1_qu5_b3_3 I1_qu5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1769_MP2_1 (VDD I1_qu5_b2_1 I1_qu5_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1766_MP2 (I1_qu5_b3_0 I1_qu5_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1766_MP2_1 (VDD I1_qu5_b2_0 I1_qu5_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I450_MP2 (I1_dd25_b3_4 I1_dd25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I450_MP2_1 (VDD I1_dd25_b2_1 I1_dd25_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I437_MP2 (I1_dd24_b3_4 I1_dd24_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I437_MP2_1 (VDD I1_dd24_b2_1 I1_dd24_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1586_MP2 (I1_qu9_b3_4 I1_qu9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1586_MP2_1 (VDD I1_qu9_b2_1 I1_qu9_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I12_MP2 (I0_A_0_b2_0 I0_A_0_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I12_MP2_1 (VDD I0_A_0_b1_0 I0_A_0_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I51_MP2 (I0_A_4_b1_0 I0_A_4_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I51_MP2_1 (VDD I0_A_4_b0 I0_A_4_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I21_MP2 (I0_A_1_b1_0 I0_A_1_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I21_MP2_1 (VDD I0_A_1_b0 I0_A_1_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I937_MP2 (I0_two8_b3_0 I0_two8_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I937_MP2_1 (VDD I0_two8_b2_0 I0_two8_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I87_MP2 (I0_A_7_b3_3 I0_A_7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I87_MP2_1 (VDD I0_A_7_b2_1 I0_A_7_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1037_MP2 (I0_one10_b3_0 I0_one10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1037_MP2_1 (VDD I0_one10_b2_0 I0_one10_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1048_MP2 (I0_two10_b3_1 I0_two10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1048_MP2_1 (VDD I0_two10_b2_0 I0_two10_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1038_MP2 (I0_one10_b3_1 I0_one10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1038_MP2_1 (VDD I0_one10_b2_0 I0_one10_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I994_MP2 (I0_two9_b3_2 I0_two9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I994_MP2_1 (VDD I0_two9_b2_0 I0_two9_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I426_MP2 (I0_B_21_b3_0 I0_B_21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I426_MP2_1 (VDD I0_B_21_b2_0 I0_B_21_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I427_MP2 (I0_B_21_b3_1 I0_B_21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I427_MP2_1 (VDD I0_B_21_b2_0 I0_B_21_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I984_MP2 (I0_one9_b3_2 I0_one9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I984_MP2_1 (VDD I0_one9_b2_0 I0_one9_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1034_MP2 (I0_one10_b1_0 I0_one10_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1034_MP2_1 (VDD I0_one10_b0 I0_one10_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I935_MP2 (I0_two8_b2_0 I0_two8_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I935_MP2_1 (VDD I0_two8_b1_0 I0_two8_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1035_MP2 (I0_one10_b2_0 I0_one10_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1035_MP2_1 (VDD I0_one10_b1_0 I0_one10_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1049_MP2 (I0_two10_b3_2 I0_two10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1049_MP2_1 (VDD I0_two10_b2_0 I0_two10_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I934_MP2 (I0_two8_b1_0 I0_two8_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I934_MP2_1 (VDD I0_two8_b0 I0_two8_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1039_MP2 (I0_one10_b3_2 I0_one10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1039_MP2_1 (VDD I0_one10_b2_0 I0_one10_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I924_MP2 (I0_one8_b1_0 I0_one8_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I924_MP2_1 (VDD I0_one8_b0 I0_one8_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I98_MP2 (I0_A_8_b3_4 I0_A_8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I98_MP2_1 (VDD I0_A_8_b2_1 I0_A_8_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I108_MP2 (I0_A_9_b3_4 I0_A_9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I108_MP2_1 (VDD I0_A_9_b2_1 I0_A_9_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I99_MP2 (I0_A_8_b3_5 I0_A_8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I99_MP2_1 (VDD I0_A_8_b2_1 I0_A_8_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I118_MP2 (I0_A_10_b3_4 I0_A_10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I118_MP2_1 (VDD I0_A_10_b2_1 I0_A_10_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I438_MP2 (I0_B_23_b3_2 I0_B_23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I438_MP2_1 (VDD I0_B_23_b2_0 I0_B_23_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I128_MP2 (I0_A_11_b3_4 I0_A_11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I128_MP2_1 (VDD I0_A_11_b2_1 I0_A_11_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I138_MP2 (I0_A_12_b3_4 I0_A_12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I138_MP2_1 (VDD I0_A_12_b2_1 I0_A_12_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I926_MP2 (I0_one8_b2_1 I0_one8_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I926_MP2_1 (VDD I0_one8_b1_0 I0_one8_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I936_MP2 (I0_two8_b2_1 I0_two8_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I936_MP2_1 (VDD I0_two8_b1_0 I0_two8_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I930_MP2 (I0_one8_b3_3 I0_one8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I930_MP2_1 (VDD I0_one8_b2_1 I0_one8_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I940_MP2 (I0_two8_b3_3 I0_two8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I940_MP2_1 (VDD I0_two8_b2_1 I0_two8_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I405_MP2 (I0_B_17_b2_1 I0_B_17_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I405_MP2_1 (VDD I0_B_17_b1_0 I0_B_17_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I409_MP2 (I0_B_17_b3_3 I0_B_17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I409_MP2_1 (VDD I0_B_17_b2_1 I0_B_17_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I415_MP2 (I0_B_19_b2_1 I0_B_19_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I415_MP2_1 (VDD I0_B_19_b1_0 I0_B_19_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I414_MP2 (I0_B_19_b2_0 I0_B_19_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I414_MP2_1 (VDD I0_B_19_b1_0 I0_B_19_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I419_MP2 (I0_B_19_b3_3 I0_B_19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I419_MP2_1 (VDD I0_B_19_b2_1 I0_B_19_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I451_MP2 (I1_dd25_b3_5 I1_dd25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I451_MP2_1 (VDD I1_dd25_b2_1 I1_dd25_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I502_MP2 (I1_dd29_b3_4 I1_dd29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I502_MP2_1 (VDD I1_dd29_b2_1 I1_dd29_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I476_MP2 (I1_dd27_b3_4 I1_dd27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I476_MP2_1 (VDD I1_dd27_b2_1 I1_dd27_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I463_MP2 (I1_dd26_b3_4 I1_dd26_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I463_MP2_1 (VDD I1_dd26_b2_1 I1_dd26_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I489_MP2 (I1_dd28_b3_4 I1_dd28_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I489_MP2_1 (VDD I1_dd28_b2_1 I1_dd28_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I204_MP2 (I1_dd6_b3_5 I1_dd6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I204_MP2_1 (VDD I1_dd6_b2_1 I1_dd6_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I191_MP2 (I1_dd5_b3_5 I1_dd5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I191_MP2_1 (VDD I1_dd5_b2_1 I1_dd5_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I139_MP2 (I1_dd1_b3_5 I1_dd1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I139_MP2_1 (VDD I1_dd1_b2_1 I1_dd1_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I165_MP2 (I1_dd3_b3_5 I1_dd3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I165_MP2_1 (VDD I1_dd3_b2_1 I1_dd3_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I41_MP2 (I0_A_3_b1_0 I0_A_3_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I41_MP2_1 (VDD I0_A_3_b0 I0_A_3_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I23_MP2 (I0_A_1_b2_1 I0_A_1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I23_MP2_1 (VDD I0_A_1_b1_0 I0_A_1_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I42_MP2 (I0_A_3_b2_0 I0_A_3_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I42_MP2_1 (VDD I0_A_3_b1_0 I0_A_3_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I63_MP2 (I0_A_5_b2_1 I0_A_5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I63_MP2_1 (VDD I0_A_5_b1_0 I0_A_5_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I10_MP2 (I1_A_31_b3_5 I1_A_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I10_MP2_1 (VDD I1_A_31_b2_1 I1_A_31_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1047_MP2 (I0_two10_b3_0 I0_two10_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1047_MP2_1 (VDD I0_two10_b2_0 I0_two10_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I983_MP2 (I0_one9_b3_1 I0_one9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I983_MP2_1 (VDD I0_one9_b2_0 I0_one9_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I416_MP2 (I0_B_19_b3_0 I0_B_19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I416_MP2_1 (VDD I0_B_19_b2_0 I0_B_19_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I417_MP2 (I0_B_19_b3_1 I0_B_19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I417_MP2_1 (VDD I0_B_19_b2_0 I0_B_19_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I989_MP2 (I0_two9_b1_0 I0_two9_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I989_MP2_1 (VDD I0_two9_b0 I0_two9_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I990_MP2 (I0_two9_b2_0 I0_two9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I990_MP2_1 (VDD I0_two9_b1_0 I0_two9_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I980_MP2 (I0_one9_b2_0 I0_one9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I980_MP2_1 (VDD I0_one9_b1_0 I0_one9_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1044_MP2 (I0_two10_b1_0 I0_two10_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1044_MP2_1 (VDD I0_two10_b0 I0_two10_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1045_MP2 (I0_two10_b2_0 I0_two10_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1045_MP2_1 (VDD I0_two10_b1_0 I0_two10_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I78_MP2 (I0_A_6_b3_4 I0_A_6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I78_MP2_1 (VDD I0_A_6_b2_1 I0_A_6_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I79_MP2 (I0_A_6_b3_5 I0_A_6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I79_MP2_1 (VDD I0_A_6_b2_1 I0_A_6_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1093_MP2 (I0_one11_b3_1 I0_one11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1093_MP2_1 (VDD I0_one11_b2_0 I0_one11_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1103_MP2 (I0_two11_b3_1 I0_two11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1103_MP2_1 (VDD I0_two11_b2_0 I0_two11_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I88_MP2 (I0_A_7_b3_4 I0_A_7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I88_MP2_1 (VDD I0_A_7_b2_1 I0_A_7_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I89_MP2 (I0_A_7_b3_5 I0_A_7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I89_MP2_1 (VDD I0_A_7_b2_1 I0_A_7_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I109_MP2 (I0_A_9_b3_5 I0_A_9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I109_MP2_1 (VDD I0_A_9_b2_1 I0_A_9_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I437_MP2 (I0_B_23_b3_1 I0_B_23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I437_MP2_1 (VDD I0_B_23_b2_0 I0_B_23_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1104_MP2 (I0_two11_b3_2 I0_two11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1104_MP2_1 (VDD I0_two11_b2_0 I0_two11_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I434_MP2 (I0_B_23_b2_0 I0_B_23_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I434_MP2_1 (VDD I0_B_23_b1_0 I0_B_23_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I119_MP2 (I0_A_10_b3_5 I0_A_10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I119_MP2_1 (VDD I0_A_10_b2_1 I0_A_10_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I129_MP2 (I0_A_11_b3_5 I0_A_11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I129_MP2_1 (VDD I0_A_11_b2_1 I0_A_11_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1046_MP2 (I0_two10_b2_1 I0_two10_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1046_MP2_1 (VDD I0_two10_b1_0 I0_two10_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1036_MP2 (I0_one10_b2_1 I0_one10_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1036_MP2_1 (VDD I0_one10_b1_0 I0_one10_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1050_MP2 (I0_two10_b3_3 I0_two10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1050_MP2_1 (VDD I0_two10_b2_1 I0_two10_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1040_MP2 (I0_one10_b3_3 I0_one10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1040_MP2_1 (VDD I0_one10_b2_1 I0_one10_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I411_MP2 (I0_B_17_b3_5 I0_B_17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I411_MP2_1 (VDD I0_B_17_b2_1 I0_B_17_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I991_MP2 (I0_two9_b2_1 I0_two9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I991_MP2_1 (VDD I0_two9_b1_0 I0_two9_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I995_MP2 (I0_two9_b3_3 I0_two9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I995_MP2_1 (VDD I0_two9_b2_1 I0_two9_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I985_MP2 (I0_one9_b3_3 I0_one9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I985_MP2_1 (VDD I0_one9_b2_1 I0_one9_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I981_MP2 (I0_one9_b2_1 I0_one9_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I981_MP2_1 (VDD I0_one9_b1_0 I0_one9_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I412_MP2 (I1_dd22_b3_5 I1_dd22_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I412_MP2_1 (VDD I1_dd22_b2_1 I1_dd22_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I464_MP2 (I1_dd26_b3_5 I1_dd26_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I464_MP2_1 (VDD I1_dd26_b2_1 I1_dd26_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I373_MP2 (I1_dd19_b3_5 I1_dd19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I373_MP2_1 (VDD I1_dd19_b2_1 I1_dd19_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I308_MP2 (I1_dd14_b3_5 I1_dd14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I308_MP2_1 (VDD I1_dd14_b2_1 I1_dd14_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I321_MP2 (I1_dd15_b3_5 I1_dd15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I321_MP2_1 (VDD I1_dd15_b2_1 I1_dd15_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I295_MP2 (I1_dd13_b3_5 I1_dd13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I295_MP2_1 (VDD I1_dd13_b2_1 I1_dd13_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I243_MP2 (I1_dd9_b3_5 I1_dd9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I243_MP2_1 (VDD I1_dd9_b2_1 I1_dd9_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I282_MP2 (I1_dd12_b3_5 I1_dd12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I282_MP2_1 (VDD I1_dd12_b2_1 I1_dd12_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I152_MP2 (I1_dd2_b3_5 I1_dd2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I152_MP2_1 (VDD I1_dd2_b2_1 I1_dd2_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I178_MP2 (I1_dd4_b3_5 I1_dd4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I178_MP2_1 (VDD I1_dd4_b2_1 I1_dd4_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I45_MP2 (I2_I3_SEL_MUL_b3_0 I2_I3_SEL_MUL_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I45_MP2_1 (VDD I2_I3_SEL_MUL_b2_0 I2_I3_SEL_MUL_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I11_MP2 (I0_A_0_b1_0 I0_A_0_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I11_MP2_1 (VDD I0_A_0_b0 I0_A_0_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I46_MP2 (I2_I3_SEL_MUL_b3_1 I2_I3_SEL_MUL_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I46_MP2_1 (VDD I2_I3_SEL_MUL_b2_0 I2_I3_SEL_MUL_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I31_MP2 (I0_A_2_b1_0 I0_A_2_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I31_MP2_1 (VDD I0_A_2_b0 I0_A_2_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I13_MP2 (I0_A_0_b2_1 I0_A_0_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I13_MP2_1 (VDD I0_A_0_b1_0 I0_A_0_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I33_MP2 (I0_A_2_b2_1 I0_A_2_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I33_MP2_1 (VDD I0_A_2_b1_0 I0_A_2_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I47_MP2 (I2_I3_SEL_MUL_b3_2 I2_I3_SEL_MUL_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I47_MP2_1 (VDD I2_I3_SEL_MUL_b2_0 I2_I3_SEL_MUL_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I43_MP2 (I0_A_3_b2_1 I0_A_3_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I43_MP2_1 (VDD I0_A_3_b1_0 I0_A_3_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I66_MP2 (I2_I3_SEL_DIV_b3_5 I2_I3_SEL_DIV_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I66_MP2_1 (VDD I2_I3_SEL_DIV_b2_1 I2_I3_SEL_DIV_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I65_MP2 (I2_I3_SEL_DIV_b3_4 I2_I3_SEL_DIV_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I65_MP2_1 (VDD I2_I3_SEL_DIV_b2_1 I2_I3_SEL_DIV_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I53_MP2 (I0_A_4_b2_1 I0_A_4_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I53_MP2_1 (VDD I0_A_4_b1_0 I0_A_4_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I48_MP2 (I2_I3_SEL_MUL_b3_3 I2_I3_SEL_MUL_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I48_MP2_1 (VDD I2_I3_SEL_MUL_b2_0 I2_I3_SEL_MUL_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I42_MP2 (I2_I3_SEL_MUL_b2_0 I2_I3_SEL_MUL_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I42_MP2_1 (VDD I2_I3_SEL_MUL_b1_0 I2_I3_SEL_MUL_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I41_MP2 (I2_I3_SEL_MUL_b1_0 I2_I3_SEL_MUL_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I41_MP2_1 (VDD I2_I3_SEL_MUL_b0 I2_I3_SEL_MUL_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I17_MP2 (I0_A_0_b3_3 I0_A_0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I17_MP2_1 (VDD I0_A_0_b2_1 I0_A_0_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I27_MP2 (I0_A_1_b3_3 I0_A_1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I27_MP2_1 (VDD I0_A_1_b2_1 I0_A_1_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I37_MP2 (I0_A_2_b3_3 I0_A_2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I37_MP2_1 (VDD I0_A_2_b2_1 I0_A_2_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I47_MP2 (I0_A_3_b3_3 I0_A_3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I47_MP2_1 (VDD I0_A_3_b2_1 I0_A_3_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I57_MP2 (I0_A_4_b3_3 I0_A_4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I57_MP2_1 (VDD I0_A_4_b2_1 I0_A_4_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I992_MP2 (I0_two9_b3_0 I0_two9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I992_MP2_1 (VDD I0_two9_b2_0 I0_two9_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I77_MP2 (I0_A_6_b3_3 I0_A_6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I77_MP2_1 (VDD I0_A_6_b2_1 I0_A_6_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I982_MP2 (I0_one9_b3_0 I0_one9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I982_MP2_1 (VDD I0_one9_b2_0 I0_one9_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I67_MP2 (I0_A_5_b3_3 I0_A_5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I67_MP2_1 (VDD I0_A_5_b2_1 I0_A_5_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I993_MP2 (I0_two9_b3_1 I0_two9_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I993_MP2_1 (VDD I0_two9_b2_0 I0_two9_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I979_MP2 (I0_one9_b1_0 I0_one9_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I979_MP2_1 (VDD I0_one9_b0 I0_one9_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I68_MP2 (I0_A_5_b3_4 I0_A_5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I68_MP2_1 (VDD I0_A_5_b2_1 I0_A_5_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I69_MP2 (I0_A_5_b3_5 I0_A_5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I69_MP2_1 (VDD I0_A_5_b2_1 I0_A_5_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1092_MP2 (I0_one11_b3_0 I0_one11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1092_MP2_1 (VDD I0_one11_b2_0 I0_one11_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1102_MP2 (I0_two11_b3_0 I0_two11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1102_MP2_1 (VDD I0_two11_b2_0 I0_two11_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I436_MP2 (I0_B_23_b3_0 I0_B_23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I436_MP2_1 (VDD I0_B_23_b2_0 I0_B_23_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1094_MP2 (I0_one11_b3_2 I0_one11_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1094_MP2_1 (VDD I0_one11_b2_0 I0_one11_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I148_MP2 (I0_A_13_b3_4 I0_A_13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I148_MP2_1 (VDD I0_A_13_b2_1 I0_A_13_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I410_MP2 (I0_B_17_b3_4 I0_B_17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I410_MP2_1 (VDD I0_B_17_b2_1 I0_B_17_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I421_MP2 (I0_B_19_b3_5 I0_B_19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I421_MP2_1 (VDD I0_B_19_b2_1 I0_B_19_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I420_MP2 (I0_B_19_b3_4 I0_B_19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I420_MP2_1 (VDD I0_B_19_b2_1 I0_B_19_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I503_MP2 (I1_dd29_b3_5 I1_dd29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I503_MP2_1 (VDD I1_dd29_b2_1 I1_dd29_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I438_MP2 (I1_dd24_b3_5 I1_dd24_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I438_MP2_1 (VDD I1_dd24_b2_1 I1_dd24_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I399_MP2 (I1_dd21_b3_5 I1_dd21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I399_MP2_1 (VDD I1_dd21_b2_1 I1_dd21_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I386_MP2 (I1_dd20_b3_5 I1_dd20_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I386_MP2_1 (VDD I1_dd20_b2_1 I1_dd20_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I516_MP2 (I1_dd30_b3_5 I1_dd30_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I516_MP2_1 (VDD I1_dd30_b2_1 I1_dd30_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I347_MP2 (I1_dd17_b3_5 I1_dd17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I347_MP2_1 (VDD I1_dd17_b2_1 I1_dd17_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I360_MP2 (I1_dd18_b3_5 I1_dd18_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I360_MP2_1 (VDD I1_dd18_b2_1 I1_dd18_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I425_MP2 (I1_dd23_b3_5 I1_dd23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I425_MP2_1 (VDD I1_dd23_b2_1 I1_dd23_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I217_MP2 (I1_dd7_b3_5 I1_dd7_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I217_MP2_1 (VDD I1_dd7_b2_1 I1_dd7_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I3_MP2 (I1_A_31_b2_1 I1_A_31_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I3_MP2_1 (VDD I1_A_31_b1_0 I1_A_31_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I48_MP2 (I0_A_3_b3_4 I0_A_3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I48_MP2_1 (VDD I0_A_3_b2_1 I0_A_3_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I38_MP2 (I0_A_2_b3_4 I0_A_2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I38_MP2_1 (VDD I0_A_2_b2_1 I0_A_2_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I39_MP2 (I0_A_2_b3_5 I0_A_2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I39_MP2_1 (VDD I0_A_2_b2_1 I0_A_2_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I49_MP2 (I0_A_3_b3_5 I0_A_3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I49_MP2_1 (VDD I0_A_3_b2_1 I0_A_3_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I447_MP2 (I0_B_25_b3_1 I0_B_25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I447_MP2_1 (VDD I0_B_25_b2_0 I0_B_25_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1148_MP2 (I0_one12_b3_1 I0_one12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1148_MP2_1 (VDD I0_one12_b2_0 I0_one12_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1213_MP2 (I0_two13_b3_1 I0_two13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1213_MP2_1 (VDD I0_two13_b2_0 I0_two13_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1149_MP2 (I0_one12_b3_2 I0_one12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1149_MP2_1 (VDD I0_one12_b2_0 I0_one12_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I444_MP2 (I0_B_25_b2_0 I0_B_25_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I444_MP2_1 (VDD I0_B_25_b1_0 I0_B_25_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I448_MP2 (I0_B_25_b3_2 I0_B_25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I448_MP2_1 (VDD I0_B_25_b2_0 I0_B_25_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1159_MP2 (I0_two12_b3_2 I0_two12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1159_MP2_1 (VDD I0_two12_b2_0 I0_two12_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I139_MP2 (I0_A_12_b3_5 I0_A_12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I139_MP2_1 (VDD I0_A_12_b2_1 I0_A_12_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I158_MP2 (I0_A_14_b3_4 I0_A_14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I158_MP2_1 (VDD I0_A_14_b2_1 I0_A_14_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1950_MP2 (I1_qu1_b3_0 I1_qu1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1950_MP2_1 (VDD I1_qu1_b2_0 I1_qu1_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I28_MP2 (I0_A_1_b3_4 I0_A_1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I28_MP2_1 (VDD I0_A_1_b2_1 I0_A_1_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I59_MP2 (I0_A_4_b3_5 I0_A_4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I59_MP2_1 (VDD I0_A_4_b2_1 I0_A_4_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I58_MP2 (I0_A_4_b3_4 I0_A_4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I58_MP2_1 (VDD I0_A_4_b2_1 I0_A_4_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1157_MP2 (I0_two12_b3_0 I0_two12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1157_MP2_1 (VDD I0_two12_b2_0 I0_two12_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1147_MP2 (I0_one12_b3_0 I0_one12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1147_MP2_1 (VDD I0_one12_b2_0 I0_one12_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1203_MP2 (I0_one13_b3_1 I0_one13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1203_MP2_1 (VDD I0_one13_b2_0 I0_one13_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I454_MP2 (I0_B_27_b2_0 I0_B_27_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I454_MP2_1 (VDD I0_B_27_b1_0 I0_B_27_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I457_MP2 (I0_B_27_b3_1 I0_B_27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I457_MP2_1 (VDD I0_B_27_b2_0 I0_B_27_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1090_MP2 (I0_one11_b2_0 I0_one11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1090_MP2_1 (VDD I0_one11_b1_0 I0_one11_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1214_MP2 (I0_two13_b3_2 I0_two13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1214_MP2_1 (VDD I0_two13_b2_0 I0_two13_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I169_MP2 (I0_A_15_b3_5 I0_A_15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I169_MP2_1 (VDD I0_A_15_b2_1 I0_A_15_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I168_MP2 (I0_A_15_b3_4 I0_A_15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I168_MP2_1 (VDD I0_A_15_b2_1 I0_A_15_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I159_MP2 (I0_A_14_b3_5 I0_A_14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I159_MP2_1 (VDD I0_A_14_b2_1 I0_A_14_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I178_MP2 (I0_A_16_b3_4 I0_A_16_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I178_MP2_1 (VDD I0_A_16_b2_1 I0_A_16_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1905_MP2 (I1_qu2_b3_1 I1_qu2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1905_MP2_1 (VDD I1_qu2_b2_0 I1_qu2_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1904_MP2 (I1_qu2_b3_0 I1_qu2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1904_MP2_1 (VDD I1_qu2_b2_0 I1_qu2_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1995_MP2 (I1_p31_32_b3_0 I1_p31_32_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1995_MP2_1 (VDD I1_p31_32_b2_0 I1_p31_32_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I49_MP2 (I2_I3_SEL_MUL_b3_4 I2_I3_SEL_MUL_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I49_MP2_1 (VDD I2_I3_SEL_MUL_b2_1 I2_I3_SEL_MUL_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I29_MP2 (I0_A_1_b3_5 I0_A_1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I29_MP2_1 (VDD I0_A_1_b2_1 I0_A_1_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I18_MP2 (I0_A_0_b3_4 I0_A_0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I18_MP2_1 (VDD I0_A_0_b2_1 I0_A_0_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I19_MP2 (I0_A_0_b3_5 I0_A_0_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I19_MP2_1 (VDD I0_A_0_b2_1 I0_A_0_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1202_MP2 (I0_one13_b3_0 I0_one13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1202_MP2_1 (VDD I0_one13_b2_0 I0_one13_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I456_MP2 (I0_B_27_b3_0 I0_B_27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I456_MP2_1 (VDD I0_B_27_b2_0 I0_B_27_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1212_MP2 (I0_two13_b3_0 I0_two13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1212_MP2_1 (VDD I0_two13_b2_0 I0_two13_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1323_MP2 (I0_two15_b3_1 I0_two15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1323_MP2_1 (VDD I0_two15_b2_0 I0_two15_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I467_MP2 (I0_B_29_b3_1 I0_B_29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I467_MP2_1 (VDD I0_B_29_b2_0 I0_B_29_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1258_MP2 (I0_one14_b3_1 I0_one14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1258_MP2_1 (VDD I0_one14_b2_0 I0_one14_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I179_MP2 (I0_A_16_b3_5 I0_A_16_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I179_MP2_1 (VDD I0_A_16_b2_1 I0_A_16_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I223_MP2 (I0_A_21_b2_1 I0_A_21_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I223_MP2_1 (VDD I0_A_21_b1_0 I0_A_21_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1204_MP2 (I0_one13_b3_2 I0_one13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1204_MP2_1 (VDD I0_one13_b2_0 I0_one13_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I458_MP2 (I0_B_27_b3_2 I0_B_27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I458_MP2_1 (VDD I0_B_27_b2_0 I0_B_27_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I149_MP2 (I0_A_13_b3_5 I0_A_13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I149_MP2_1 (VDD I0_A_13_b2_1 I0_A_13_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I425_MP2 (I0_B_21_b2_1 I0_B_21_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I425_MP2_1 (VDD I0_B_21_b1_0 I0_B_21_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1812_MP2 (I1_qu4_b3_0 I1_qu4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1812_MP2_1 (VDD I1_qu4_b2_0 I1_qu4_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1858_MP2 (I1_qu3_b3_0 I1_qu3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1858_MP2_1 (VDD I1_qu3_b2_0 I1_qu3_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I256_MP2 (I1_dd10_b3_5 I1_dd10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I256_MP2_1 (VDD I1_dd10_b2_1 I1_dd10_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1951_MP2 (I1_qu1_b3_1 I1_qu1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1951_MP2_1 (VDD I1_qu1_b2_0 I1_qu1_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1996_MP2 (I1_p31_32_b3_1 I1_p31_32_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1996_MP2_1 (VDD I1_p31_32_b2_0 I1_p31_32_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1257_MP2 (I0_one14_b3_0 I0_one14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1257_MP2_1 (VDD I0_one14_b2_0 I0_one14_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1155_MP2 (I0_two12_b2_0 I0_two12_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1155_MP2_1 (VDD I0_two12_b1_0 I0_two12_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1267_MP2 (I0_two14_b3_0 I0_two14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1267_MP2_1 (VDD I0_two14_b2_0 I0_two14_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1312_MP2 (I0_one15_b3_0 I0_one15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1312_MP2_1 (VDD I0_one15_b2_0 I0_one15_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1322_MP2 (I0_two15_b3_0 I0_two15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1322_MP2_1 (VDD I0_two15_b2_0 I0_two15_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I477_MP2 (I0_B_31_b3_1 I0_B_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I477_MP2_1 (VDD I0_B_31_b2_0 I0_B_31_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1100_MP2 (I0_two11_b2_0 I0_two11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1100_MP2_1 (VDD I0_two11_b1_0 I0_two11_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I464_MP2 (I0_B_29_b2_0 I0_B_29_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I464_MP2_1 (VDD I0_B_29_b1_0 I0_B_29_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I466_MP2 (I0_B_29_b3_0 I0_B_29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I466_MP2_1 (VDD I0_B_29_b2_0 I0_B_29_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1313_MP2 (I0_one15_b3_1 I0_one15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1313_MP2_1 (VDD I0_one15_b2_0 I0_one15_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I468_MP2 (I0_B_29_b3_2 I0_B_29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I468_MP2_1 (VDD I0_B_29_b2_0 I0_B_29_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1269_MP2 (I0_two14_b3_2 I0_two14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1269_MP2_1 (VDD I0_two14_b2_0 I0_two14_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1268_MP2 (I0_two14_b3_1 I0_two14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1268_MP2_1 (VDD I0_two14_b2_0 I0_two14_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I227_MP2 (I0_A_21_b3_3 I0_A_21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I227_MP2_1 (VDD I0_A_21_b2_1 I0_A_21_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I931_MP2 (I0_one8_b3_4 I0_one8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I931_MP2_1 (VDD I0_one8_b2_1 I0_one8_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I941_MP2 (I0_two8_b3_4 I0_two8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I941_MP2_1 (VDD I0_two8_b2_1 I0_two8_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1859_MP2 (I1_qu3_b3_1 I1_qu3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1859_MP2_1 (VDD I1_qu3_b2_0 I1_qu3_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1145_MP2 (I0_one12_b2_0 I0_one12_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1145_MP2_1 (VDD I0_one12_b1_0 I0_one12_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I473_MP2 (I0_B_31_b1_0 I0_B_31_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I473_MP2_1 (VDD I0_B_31_b0 I0_B_31_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1310_MP2 (I0_one15_b2_0 I0_one15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1310_MP2_1 (VDD I0_one15_b1_0 I0_one15_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1089_MP2 (I0_one11_b1_0 I0_one11_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1089_MP2_1 (VDD I0_one11_b0 I0_one11_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I478_MP2 (I0_B_31_b3_2 I0_B_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I478_MP2_1 (VDD I0_B_31_b2_0 I0_B_31_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1314_MP2 (I0_one15_b3_2 I0_one15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1314_MP2_1 (VDD I0_one15_b2_0 I0_one15_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1259_MP2 (I0_one14_b3_2 I0_one14_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1259_MP2_1 (VDD I0_one14_b2_0 I0_one14_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I431_MP2 (I0_B_21_b3_5 I0_B_21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I431_MP2_1 (VDD I0_B_21_b2_1 I0_B_21_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I429_MP2 (I0_B_21_b3_3 I0_B_21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I429_MP2_1 (VDD I0_B_21_b2_1 I0_B_21_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1051_MP2 (I0_two10_b3_4 I0_two10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1051_MP2_1 (VDD I0_two10_b2_1 I0_two10_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1813_MP2 (I1_qu4_b3_1 I1_qu4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1813_MP2_1 (VDD I1_qu4_b2_0 I1_qu4_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1997_MP2 (I1_p31_32_b3_2 I1_p31_32_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1997_MP2_1 (VDD I1_p31_32_b2_0 I1_p31_32_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1993_MP2 (I1_p31_32_b2_0 I1_p31_32_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1993_MP2_1 (VDD I1_p31_32_b1_0 I1_p31_32_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I4_MP2 (I1_A_31_b2_2 I1_A_31_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I4_MP2_1 (VDD I1_A_31_b1_0 I1_A_31_b2_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1209_MP2 (I0_two13_b1_0 I0_two13_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1209_MP2_1 (VDD I0_two13_b0 I0_two13_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1199_MP2 (I0_one13_b1_0 I0_one13_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1199_MP2_1 (VDD I0_one13_b0 I0_one13_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1200_MP2 (I0_one13_b2_0 I0_one13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1200_MP2_1 (VDD I0_one13_b1_0 I0_one13_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1210_MP2 (I0_two13_b2_0 I0_two13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1210_MP2_1 (VDD I0_two13_b1_0 I0_two13_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1154_MP2 (I0_two12_b1_0 I0_two12_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1154_MP2_1 (VDD I0_two12_b0 I0_two12_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1144_MP2 (I0_one12_b1_0 I0_one12_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1144_MP2_1 (VDD I0_one12_b0 I0_one12_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I474_MP2 (I0_B_31_b2_0 I0_B_31_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I474_MP2_1 (VDD I0_B_31_b1_0 I0_B_31_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I476_MP2 (I0_B_31_b3_0 I0_B_31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I476_MP2_1 (VDD I0_B_31_b2_0 I0_B_31_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1099_MP2 (I0_two11_b1_0 I0_two11_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1099_MP2_1 (VDD I0_two11_b0 I0_two11_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1320_MP2 (I0_two15_b2_0 I0_two15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1320_MP2_1 (VDD I0_two15_b1_0 I0_two15_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1324_MP2 (I0_two15_b3_2 I0_two15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1324_MP2_1 (VDD I0_two15_b2_0 I0_two15_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I233_MP2 (I0_A_22_b2_1 I0_A_22_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I233_MP2_1 (VDD I0_A_22_b1_0 I0_A_22_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I243_MP2 (I0_A_23_b2_1 I0_A_23_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I243_MP2_1 (VDD I0_A_23_b1_0 I0_A_23_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I253_MP2 (I0_A_24_b2_1 I0_A_24_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I253_MP2_1 (VDD I0_A_24_b1_0 I0_A_24_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I247_MP2 (I0_A_23_b3_3 I0_A_23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I247_MP2_1 (VDD I0_A_23_b2_1 I0_A_23_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I257_MP2 (I0_A_24_b3_3 I0_A_24_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I257_MP2_1 (VDD I0_A_24_b2_1 I0_A_24_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I237_MP2 (I0_A_22_b3_3 I0_A_22_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I237_MP2_1 (VDD I0_A_22_b2_1 I0_A_22_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I430_MP2 (I0_B_21_b3_4 I0_B_21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I430_MP2_1 (VDD I0_B_21_b2_1 I0_B_21_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1041_MP2 (I0_one10_b3_4 I0_one10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1041_MP2_1 (VDD I0_one10_b2_1 I0_one10_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I996_MP2 (I0_two9_b3_4 I0_two9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I996_MP2_1 (VDD I0_two9_b2_1 I0_two9_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I986_MP2 (I0_one9_b3_4 I0_one9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I986_MP2_1 (VDD I0_one9_b2_1 I0_one9_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1906_MP2 (I1_qu2_b3_2 I1_qu2_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1906_MP2_1 (VDD I1_qu2_b2_0 I1_qu2_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1952_MP2 (I1_qu1_b3_2 I1_qu1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1952_MP2_1 (VDD I1_qu1_b2_0 I1_qu1_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1264_MP2 (I0_two14_b1_0 I0_two14_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1264_MP2_1 (VDD I0_two14_b0 I0_two14_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1265_MP2 (I0_two14_b2_0 I0_two14_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1265_MP2_1 (VDD I0_two14_b1_0 I0_two14_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1255_MP2 (I0_one14_b2_0 I0_one14_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1255_MP2_1 (VDD I0_one14_b1_0 I0_one14_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1146_MP2 (I0_one12_b2_1 I0_one12_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1146_MP2_1 (VDD I0_one12_b1_0 I0_one12_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1309_MP2 (I0_one15_b1_0 I0_one15_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1309_MP2_1 (VDD I0_one15_b0 I0_one15_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I455_MP2 (I0_B_27_b2_1 I0_B_27_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I455_MP2_1 (VDD I0_B_27_b1_0 I0_B_27_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1319_MP2 (I0_two15_b1_0 I0_two15_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1319_MP2_1 (VDD I0_two15_b0 I0_two15_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I441_MP2 (I0_B_23_b3_5 I0_B_23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I441_MP2_1 (VDD I0_B_23_b2_1 I0_B_23_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I445_MP2 (I0_B_25_b2_1 I0_B_25_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I445_MP2_1 (VDD I0_B_25_b1_0 I0_B_25_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I440_MP2 (I0_B_23_b3_4 I0_B_23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I440_MP2_1 (VDD I0_B_23_b2_1 I0_B_23_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I439_MP2 (I0_B_23_b3_3 I0_B_23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I439_MP2_1 (VDD I0_B_23_b2_1 I0_B_23_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I435_MP2 (I0_B_23_b2_1 I0_B_23_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I435_MP2_1 (VDD I0_B_23_b1_0 I0_B_23_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I449_MP2 (I0_B_25_b3_3 I0_B_25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I449_MP2_1 (VDD I0_B_25_b2_1 I0_B_25_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I198_MP2 (I0_A_18_b3_4 I0_A_18_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I198_MP2_1 (VDD I0_A_18_b2_1 I0_A_18_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I189_MP2 (I0_A_17_b3_5 I0_A_17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I189_MP2_1 (VDD I0_A_17_b2_1 I0_A_17_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I188_MP2 (I0_A_17_b3_4 I0_A_17_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I188_MP2_1 (VDD I0_A_17_b2_1 I0_A_17_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I273_MP2 (I0_A_26_b2_1 I0_A_26_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I273_MP2_1 (VDD I0_A_26_b1_0 I0_A_26_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I263_MP2 (I0_A_25_b2_1 I0_A_25_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I263_MP2_1 (VDD I0_A_25_b1_0 I0_A_25_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I277_MP2 (I0_A_26_b3_3 I0_A_26_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I277_MP2_1 (VDD I0_A_26_b2_1 I0_A_26_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I267_MP2 (I0_A_25_b3_3 I0_A_25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I267_MP2_1 (VDD I0_A_25_b2_1 I0_A_25_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1807_MP2 (I1_qu4 I1_p27_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1807_MP2_1 (VDD I1_p27_32 I1_qu4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1809_MP2 (I1_qu4_b1_0 I1_qu4_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1809_MP2_1 (VDD I1_qu4_b0 I1_qu4_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1860_MP2 (I1_qu3_b3_2 I1_qu3_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1860_MP2_1 (VDD I1_qu3_b2_0 I1_qu3_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I11_MP2 (I1_A_31_b3_6 I1_A_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I11_MP2_1 (VDD I1_A_31_b2_1 I1_A_31_b3_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1254_MP2 (I0_one14_b1_0 I0_one14_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1254_MP2_1 (VDD I0_one14_b0 I0_one14_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I461_MP2 (I0_B_27_b3_5 I0_B_27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I461_MP2_1 (VDD I0_B_27_b2_1 I0_B_27_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I459_MP2 (I0_B_27_b3_3 I0_B_27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I459_MP2_1 (VDD I0_B_27_b2_1 I0_B_27_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I465_MP2 (I0_B_29_b2_1 I0_B_29_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I465_MP2_1 (VDD I0_B_29_b1_0 I0_B_29_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1091_MP2 (I0_one11_b2_1 I0_one11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1091_MP2_1 (VDD I0_one11_b1_0 I0_one11_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I208_MP2 (I0_A_19_b3_4 I0_A_19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I208_MP2_1 (VDD I0_A_19_b2_1 I0_A_19_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I283_MP2 (I0_A_27_b2_1 I0_A_27_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I283_MP2_1 (VDD I0_A_27_b1_0 I0_A_27_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I313_MP2 (I0_A_30_b2_1 I0_A_30_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I313_MP2_1 (VDD I0_A_30_b1_0 I0_A_30_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I293_MP2 (I0_A_28_b2_1 I0_A_28_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I293_MP2_1 (VDD I0_A_28_b1_0 I0_A_28_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I287_MP2 (I0_A_27_b3_3 I0_A_27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I287_MP2_1 (VDD I0_A_27_b2_1 I0_A_27_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I932_MP2 (I0_one8_b3_5 I0_one8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I932_MP2_1 (VDD I0_one8_b2_1 I0_one8_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1810_MP2 (I1_qu4_b2_0 I1_qu4_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1810_MP2_1 (VDD I1_qu4_b1_0 I1_qu4_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1814_MP2 (I1_qu4_b3_2 I1_qu4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1814_MP2_1 (VDD I1_qu4_b2_0 I1_qu4_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1856_MP2 (I1_qu3_b2_0 I1_qu3_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1856_MP2_1 (VDD I1_qu3_b1_0 I1_qu3_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I318_MP2 (I0_A_30_b3_4 I0_A_30_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I318_MP2_1 (VDD I0_A_30_b2_1 I0_A_30_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1201_MP2 (I0_one13_b2_1 I0_one13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1201_MP2_1 (VDD I0_one13_b1_0 I0_one13_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1211_MP2 (I0_two13_b2_1 I0_two13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1211_MP2_1 (VDD I0_two13_b1_0 I0_two13_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1256_MP2 (I0_one14_b2_1 I0_one14_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1256_MP2_1 (VDD I0_one14_b1_0 I0_one14_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1266_MP2 (I0_two14_b2_1 I0_two14_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1266_MP2_1 (VDD I0_two14_b1_0 I0_two14_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1162_MP2 (I0_two12_b3_5 I0_two12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1162_MP2_1 (VDD I0_two12_b2_1 I0_two12_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I475_MP2 (I0_B_31_b2_1 I0_B_31_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I475_MP2_1 (VDD I0_B_31_b1_0 I0_B_31_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1152_MP2 (I0_one12_b3_5 I0_one12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1152_MP2_1 (VDD I0_one12_b2_1 I0_one12_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1311_MP2 (I0_one15_b2_1 I0_one15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1311_MP2_1 (VDD I0_one15_b1_0 I0_one15_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1321_MP2 (I0_two15_b2_1 I0_two15_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1321_MP2_1 (VDD I0_two15_b1_0 I0_two15_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1101_MP2 (I0_two11_b2_1 I0_two11_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1101_MP2_1 (VDD I0_two11_b1_0 I0_two11_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I450_MP2 (I0_B_25_b3_4 I0_B_25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I450_MP2_1 (VDD I0_B_25_b2_1 I0_B_25_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1215_MP2 (I0_two13_b3_3 I0_two13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1215_MP2_1 (VDD I0_two13_b2_1 I0_two13_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1205_MP2 (I0_one13_b3_3 I0_one13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1205_MP2_1 (VDD I0_one13_b2_1 I0_one13_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I199_MP2 (I0_A_18_b3_5 I0_A_18_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I199_MP2_1 (VDD I0_A_18_b2_1 I0_A_18_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I228_MP2 (I0_A_21_b3_4 I0_A_21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I228_MP2_1 (VDD I0_A_21_b2_1 I0_A_21_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I219_MP2 (I0_A_20_b3_5 I0_A_20_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I219_MP2_1 (VDD I0_A_20_b2_1 I0_A_20_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I209_MP2 (I0_A_19_b3_5 I0_A_19_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I209_MP2_1 (VDD I0_A_19_b2_1 I0_A_19_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I218_MP2 (I0_A_20_b3_4 I0_A_20_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I218_MP2_1 (VDD I0_A_20_b2_1 I0_A_20_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1150_MP2 (I0_one12_b3_3 I0_one12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1150_MP2_1 (VDD I0_one12_b2_1 I0_one12_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1160_MP2 (I0_two12_b3_3 I0_two12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1160_MP2_1 (VDD I0_two12_b2_1 I0_two12_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1052_MP2 (I0_two10_b3_5 I0_two10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1052_MP2_1 (VDD I0_two10_b2_1 I0_two10_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I942_MP2 (I0_two8_b3_5 I0_two8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I942_MP2_1 (VDD I0_two8_b2_1 I0_two8_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I997_MP2 (I0_two9_b3_5 I0_two9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I997_MP2_1 (VDD I0_two9_b2_1 I0_two9_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1853_MP2 (I1_qu3 I1_p28_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1853_MP2_1 (VDD I1_p28_32 I1_qu3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1855_MP2 (I1_qu3_b1_0 I1_qu3_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1855_MP2_1 (VDD I1_qu3_b0 I1_qu3_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I12_MP2 (I1_A_31_b3_7 I1_A_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I12_MP2_1 (VDD I1_A_31_b2_1 I1_A_31_b3_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I67_MP2 (I2_I3_SEL_DIV_b3_6 I2_I3_SEL_DIV_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I67_MP2_1 (VDD I2_I3_SEL_DIV_b2_1 I2_I3_SEL_DIV_b3_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I51_MP2 (I2_I3_SEL_MUL_b3_6 I2_I3_SEL_MUL_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I51_MP2_1 (VDD I2_I3_SEL_MUL_b2_1 I2_I3_SEL_MUL_b3_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I319_MP2 (I0_A_30_b3_5 I0_A_30_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I319_MP2_1 (VDD I0_A_30_b2_1 I0_A_30_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I330_MP2 (I0_A_31_b3_6 I0_A_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I330_MP2_1 (VDD I0_A_31_b2_1 I0_A_31_b3_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I299_MP2 (I0_A_28_b3_5 I0_A_28_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I299_MP2_1 (VDD I0_A_28_b2_1 I0_A_28_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I308_MP2 (I0_A_29_b3_4 I0_A_29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I308_MP2_1 (VDD I0_A_29_b2_1 I0_A_29_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1207_MP2 (I0_one13_b3_5 I0_one13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1207_MP2_1 (VDD I0_one13_b2_1 I0_one13_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1217_MP2 (I0_two13_b3_5 I0_two13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1217_MP2_1 (VDD I0_two13_b2_1 I0_two13_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I298_MP2 (I0_A_28_b3_4 I0_A_28_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I298_MP2_1 (VDD I0_A_28_b2_1 I0_A_28_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I289_MP2 (I0_A_27_b3_5 I0_A_27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I289_MP2_1 (VDD I0_A_27_b2_1 I0_A_27_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1107_MP2 (I0_two11_b3_5 I0_two11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1107_MP2_1 (VDD I0_two11_b2_1 I0_two11_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1097_MP2 (I0_one11_b3_5 I0_one11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1097_MP2_1 (VDD I0_one11_b2_1 I0_one11_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1216_MP2 (I0_two13_b3_4 I0_two13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1216_MP2_1 (VDD I0_two13_b2_1 I0_two13_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1206_MP2 (I0_one13_b3_4 I0_one13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1206_MP2_1 (VDD I0_one13_b2_1 I0_one13_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I288_MP2 (I0_A_27_b3_4 I0_A_27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I288_MP2_1 (VDD I0_A_27_b2_1 I0_A_27_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1161_MP2 (I0_two12_b3_4 I0_two12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1161_MP2_1 (VDD I0_two12_b2_1 I0_two12_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1151_MP2 (I0_one12_b3_4 I0_one12_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1151_MP2_1 (VDD I0_one12_b2_1 I0_one12_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1096_MP2 (I0_one11_b3_4 I0_one11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1096_MP2_1 (VDD I0_one11_b2_1 I0_one11_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1106_MP2 (I0_two11_b3_4 I0_two11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1106_MP2_1 (VDD I0_two11_b2_1 I0_two11_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1042_MP2 (I0_one10_b3_5 I0_one10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1042_MP2_1 (VDD I0_one10_b2_1 I0_one10_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I297_MP2 (I0_A_28_b3_3 I0_A_28_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I297_MP2_1 (VDD I0_A_28_b2_1 I0_A_28_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I303_MP2 (I0_A_29_b2_1 I0_A_29_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I303_MP2_1 (VDD I0_A_29_b1_0 I0_A_29_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I59_MP2 (I2_I3_SEL_DIV_b2_1 I2_I3_SEL_DIV_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I59_MP2_1 (VDD I2_I3_SEL_DIV_b1_0 I2_I3_SEL_DIV_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I68_MP2 (I2_I3_SEL_DIV_b3_7 I2_I3_SEL_DIV_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I68_MP2_1 (VDD I2_I3_SEL_DIV_b2_1 I2_I3_SEL_DIV_b3_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I52_MP2 (I2_I3_SEL_MUL_b3_7 I2_I3_SEL_MUL_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I52_MP2_1 (VDD I2_I3_SEL_MUL_b2_1 I2_I3_SEL_MUL_b3_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I329_MP2 (I0_A_31_b3_5 I0_A_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I329_MP2_1 (VDD I0_A_31_b2_1 I0_A_31_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I229_MP2 (I0_A_21_b3_5 I0_A_21_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I229_MP2_1 (VDD I0_A_21_b2_1 I0_A_21_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I238_MP2 (I0_A_22_b3_4 I0_A_22_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I238_MP2_1 (VDD I0_A_22_b2_1 I0_A_22_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I317_MP2 (I0_A_30_b3_3 I0_A_30_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I317_MP2_1 (VDD I0_A_30_b2_1 I0_A_30_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I307_MP2 (I0_A_29_b3_3 I0_A_29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I307_MP2_1 (VDD I0_A_29_b2_1 I0_A_29_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I323_MP2 (I0_A_31_b2_1 I0_A_31_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I323_MP2_1 (VDD I0_A_31_b1_0 I0_A_31_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I987_MP2 (I0_one9_b3_5 I0_one9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I987_MP2_1 (VDD I0_one9_b2_1 I0_one9_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I44_MP2 (I2_I3_SEL_MUL_b2_2 I2_I3_SEL_MUL_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I44_MP2_1 (VDD I2_I3_SEL_MUL_b1_0 I2_I3_SEL_MUL_b2_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I309_MP2 (I0_A_29_b3_5 I0_A_29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I309_MP2_1 (VDD I0_A_29_b2_1 I0_A_29_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I469_MP2 (I0_B_29_b3_3 I0_B_29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I469_MP2_1 (VDD I0_B_29_b2_1 I0_B_29_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I470_MP2 (I0_B_29_b3_4 I0_B_29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I470_MP2_1 (VDD I0_B_29_b2_1 I0_B_29_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1260_MP2 (I0_one14_b3_3 I0_one14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1260_MP2_1 (VDD I0_one14_b2_1 I0_one14_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1270_MP2 (I0_two14_b3_3 I0_two14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1270_MP2_1 (VDD I0_two14_b2_1 I0_two14_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I249_MP2 (I0_A_23_b3_5 I0_A_23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I249_MP2_1 (VDD I0_A_23_b2_1 I0_A_23_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I248_MP2 (I0_A_23_b3_4 I0_A_23_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I248_MP2_1 (VDD I0_A_23_b2_1 I0_A_23_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I258_MP2 (I0_A_24_b3_4 I0_A_24_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I258_MP2_1 (VDD I0_A_24_b2_1 I0_A_24_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1902_MP2 (I1_qu2_b2_0 I1_qu2_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1902_MP2_1 (VDD I1_qu2_b1_0 I1_qu2_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1948_MP2 (I1_qu1_b2_0 I1_qu1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1948_MP2_1 (VDD I1_qu1_b1_0 I1_qu1_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1994_MP2 (I1_p31_32_b2_1 I1_p31_32_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1994_MP2_1 (VDD I1_p31_32_b1_0 I1_p31_32_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I60_MP2 (I2_I3_SEL_DIV_b2_2 I2_I3_SEL_DIV_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I60_MP2_1 (VDD I2_I3_SEL_DIV_b1_0 I2_I3_SEL_DIV_b2_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1272_MP2 (I0_two14_b3_5 I0_two14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1272_MP2_1 (VDD I0_two14_b2_1 I0_two14_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1262_MP2 (I0_one14_b3_5 I0_one14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1262_MP2_1 (VDD I0_one14_b2_1 I0_one14_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1261_MP2 (I0_one14_b3_4 I0_one14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1261_MP2_1 (VDD I0_one14_b2_1 I0_one14_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1325_MP2 (I0_two15_b3_3 I0_two15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1325_MP2_1 (VDD I0_two15_b2_1 I0_two15_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I239_MP2 (I0_A_22_b3_5 I0_A_22_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I239_MP2_1 (VDD I0_A_22_b2_1 I0_A_22_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I259_MP2 (I0_A_24_b3_5 I0_A_24_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I259_MP2_1 (VDD I0_A_24_b2_1 I0_A_24_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I328_MP2 (I0_A_31_b3_4 I0_A_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I328_MP2_1 (VDD I0_A_31_b2_1 I0_A_31_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1949_MP2 (I1_qu1_b2_1 I1_qu1_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1949_MP2_1 (VDD I1_qu1_b1_0 I1_qu1_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1953_MP2 (I1_qu1_b3_3 I1_qu1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1953_MP2_1 (VDD I1_qu1_b2_1 I1_qu1_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1998_MP2 (I1_p31_32_b3_3 I1_p31_32_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1998_MP2_1 (VDD I1_p31_32_b2_1 I1_p31_32_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1992_MP2 (I1_p31_32_b1_0 I1_p31_32_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1992_MP2_1 (VDD I1_p31_32_b0 I1_p31_32_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I13_MP2 (I1_A_31_b3_8 I1_A_31_b2_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I13_MP2_1 (VDD I1_A_31_b2_2 I1_A_31_b3_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I480_MP2 (I0_B_31_b3_4 I0_B_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I480_MP2_1 (VDD I0_B_31_b2_1 I0_B_31_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1316_MP2 (I0_one15_b3_4 I0_one15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1316_MP2_1 (VDD I0_one15_b2_1 I0_one15_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I479_MP2 (I0_B_31_b3_3 I0_B_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I479_MP2_1 (VDD I0_B_31_b2_1 I0_B_31_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1271_MP2 (I0_two14_b3_4 I0_two14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1271_MP2_1 (VDD I0_two14_b2_1 I0_two14_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1326_MP2 (I0_two15_b3_4 I0_two15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1326_MP2_1 (VDD I0_two15_b2_1 I0_two15_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1315_MP2 (I0_one15_b3_3 I0_one15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1315_MP2_1 (VDD I0_one15_b2_1 I0_one15_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I268_MP2 (I0_A_25_b3_4 I0_A_25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I268_MP2_1 (VDD I0_A_25_b2_1 I0_A_25_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1816_MP2 (I1_qu4_b3_4 I1_qu4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1816_MP2_1 (VDD I1_qu4_b2_1 I1_qu4_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1817_MP2 (I1_qu4_b3_5 I1_qu4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1817_MP2_1 (VDD I1_qu4_b2_1 I1_qu4_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1815_MP2 (I1_qu4_b3_3 I1_qu4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1815_MP2_1 (VDD I1_qu4_b2_1 I1_qu4_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1811_MP2 (I1_qu4_b2_1 I1_qu4_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1811_MP2_1 (VDD I1_qu4_b1_0 I1_qu4_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1862_MP2 (I1_qu3_b3_4 I1_qu3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1862_MP2_1 (VDD I1_qu3_b2_1 I1_qu3_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1863_MP2 (I1_qu3_b3_5 I1_qu3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1863_MP2_1 (VDD I1_qu3_b2_1 I1_qu3_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1861_MP2 (I1_qu3_b3_3 I1_qu3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1861_MP2_1 (VDD I1_qu3_b2_1 I1_qu3_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1857_MP2 (I1_qu3_b2_1 I1_qu3_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1857_MP2_1 (VDD I1_qu3_b1_0 I1_qu3_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1907_MP2 (I1_qu2_b3_3 I1_qu2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1907_MP2_1 (VDD I1_qu2_b2_1 I1_qu2_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1903_MP2 (I1_qu2_b2_1 I1_qu2_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1903_MP2_1 (VDD I1_qu2_b1_0 I1_qu2_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1909_MP2 (I1_qu2_b3_5 I1_qu2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1909_MP2_1 (VDD I1_qu2_b2_1 I1_qu2_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1954_MP2 (I1_qu1_b3_4 I1_qu1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1954_MP2_1 (VDD I1_qu1_b2_1 I1_qu1_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1955_MP2 (I1_qu1_b3_5 I1_qu1_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1955_MP2_1 (VDD I1_qu1_b2_1 I1_qu1_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I69_MP2 (I2_I3_SEL_DIV_b3_8 I2_I3_SEL_DIV_b2_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I69_MP2_1 (VDD I2_I3_SEL_DIV_b2_2 I2_I3_SEL_DIV_b3_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I53_MP2 (I2_I3_SEL_MUL_b3_8 I2_I3_SEL_MUL_b2_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I53_MP2_1 (VDD I2_I3_SEL_MUL_b2_2 I2_I3_SEL_MUL_b3_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I331_MP2 (I0_A_31_b3_7 I0_A_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I331_MP2_1 (VDD I0_A_31_b2_1 I0_A_31_b3_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I279_MP2 (I0_A_26_b3_5 I0_A_26_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I279_MP2_1 (VDD I0_A_26_b2_1 I0_A_26_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I269_MP2 (I0_A_25_b3_5 I0_A_25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I269_MP2_1 (VDD I0_A_25_b2_1 I0_A_25_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I278_MP2 (I0_A_26_b3_4 I0_A_26_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I278_MP2_1 (VDD I0_A_26_b2_1 I0_A_26_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1908_MP2 (I1_qu2_b3_4 I1_qu2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1908_MP2_1 (VDD I1_qu2_b2_1 I1_qu2_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1947_MP2 (I1_qu1_b1_0 I1_qu1_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1947_MP2_1 (VDD I1_qu1_b0 I1_qu1_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1999_MP2 (I1_p31_32_b3_4 I1_p31_32_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1999_MP2_1 (VDD I1_p31_32_b2_1 I1_p31_32_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I14_MP2 (I1_A_31_b3_9 I1_A_31_b2_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I14_MP2_1 (VDD I1_A_31_b2_2 I1_A_31_b3_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I70_MP2 (I2_I3_SEL_DIV_b3_9 I2_I3_SEL_DIV_b2_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I70_MP2_1 (VDD I2_I3_SEL_DIV_b2_2 I2_I3_SEL_DIV_b3_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I54_MP2 (I2_I3_SEL_MUL_b3_9 I2_I3_SEL_MUL_b2_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I54_MP2_1 (VDD I2_I3_SEL_MUL_b2_2 I2_I3_SEL_MUL_b3_9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1899_MP2 (I1_qu2 I1_p29_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1899_MP2_1 (VDD I1_p29_32 I1_qu2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1901_MP2 (I1_qu2_b1_0 I1_qu2_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1901_MP2_1 (VDD I1_qu2_b0 I1_qu2_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1945_MP2 (I1_qu1 I1_p30_32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1945_MP2_1 (VDD I1_p30_32 I1_qu1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I2000_MP2 (I1_p31_32_b3_5 I1_p31_32_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I2000_MP2_1 (VDD I1_p31_32_b2_1 I1_p31_32_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I15_MP2 (I1_A_31_b3_10 I1_A_31_b2_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I15_MP2_1 (VDD I1_A_31_b2_2 I1_A_31_b3_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I71_MP2 (I2_I3_SEL_DIV_b3_10 I2_I3_SEL_DIV_b2_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I71_MP2_1 (VDD I2_I3_SEL_DIV_b2_2 I2_I3_SEL_DIV_b3_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I55_MP2 (I2_I3_SEL_MUL_b3_10 I2_I3_SEL_MUL_b2_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I55_MP2_1 (VDD I2_I3_SEL_MUL_b2_2 I2_I3_SEL_MUL_b3_10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1613_MP9 (XI0_I1613_xp1 I0_fa138_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1613_MP11 (I0_ha252_0 XI0_I1613_xan XI0_I1613_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1613_MP12 (XI0_I1613_xp1 XI0_I1613_xbn I0_ha252_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1613_MP10 (VDD I0_B_9_b3_5 XI0_I1613_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1613_MP2 (VDD I0_fa138_0 XI0_I1613_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1613_MP16 (XI0_I1613_con I0_B_9_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1613_MP15 (VDD I0_fa138_0 XI0_I1613_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1613_MP18 (VDD XI0_I1613_con I0_ha252_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1613_MP4 (XI0_I1613_xbn I0_B_9_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1615_MP9 (XI0_I1615_xp1 I0_fa139_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1615_MP11 (I0_ha254_0 XI0_I1615_xan XI0_I1615_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1615_MP12 (XI0_I1615_xp1 XI0_I1615_xbn I0_ha254_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1615_MP10 (VDD I0_fa140_0 XI0_I1615_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1615_MP2 (VDD I0_fa139_1 XI0_I1615_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1615_MP16 (XI0_I1615_con I0_fa140_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1615_MP15 (VDD I0_fa139_1 XI0_I1615_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1615_MP18 (VDD XI0_I1615_con I0_ha254_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1615_MP4 (XI0_I1615_xbn I0_fa140_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1617_MP9 (XI0_I1617_xp1 I0_cm141_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1617_MP11 (I0_ha256_0 XI0_I1617_xan XI0_I1617_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1617_MP12 (XI0_I1617_xp1 XI0_I1617_xbn I0_ha256_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1617_MP10 (VDD I0_cm142_0 XI0_I1617_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1617_MP2 (VDD I0_cm141_1 XI0_I1617_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1617_MP16 (XI0_I1617_con I0_cm142_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1617_MP15 (VDD I0_cm141_1 XI0_I1617_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1617_MP18 (VDD XI0_I1617_con I0_ha256_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1617_MP4 (XI0_I1617_xbn I0_cm142_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1620_MP9 (XI0_I1620_xp1 I0_cm144_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1620_MP11 (I0_ha259_0 XI0_I1620_xan XI0_I1620_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1620_MP12 (XI0_I1620_xp1 XI0_I1620_xbn I0_ha259_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1620_MP10 (VDD I0_cm145_0 XI0_I1620_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1620_MP2 (VDD I0_cm144_1 XI0_I1620_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1620_MP16 (XI0_I1620_con I0_cm145_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1620_MP15 (VDD I0_cm144_1 XI0_I1620_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1620_MP18 (VDD XI0_I1620_con I0_ha259_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1620_MP4 (XI0_I1620_xbn I0_cm145_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1619_MP9 (XI0_I1619_xp1 I0_cm143_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1619_MP11 (I0_ha258_0 XI0_I1619_xan XI0_I1619_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1619_MP12 (XI0_I1619_xp1 XI0_I1619_xbn I0_ha258_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1619_MP10 (VDD I0_cm144_0 XI0_I1619_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1619_MP2 (VDD I0_cm143_1 XI0_I1619_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1619_MP16 (XI0_I1619_con I0_cm144_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1619_MP15 (VDD I0_cm143_1 XI0_I1619_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1619_MP18 (VDD XI0_I1619_con I0_ha258_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1619_MP4 (XI0_I1619_xbn I0_cm144_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1612_MP9 (XI0_I1612_xp1 I0_cm4_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1612_MP11 (I0_ha251_0 XI0_I1612_xan XI0_I1612_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1612_MP12 (XI0_I1612_xp1 XI0_I1612_xbn I0_ha251_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1612_MP10 (VDD I0_cm5_0 XI0_I1612_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1612_MP2 (VDD I0_cm4_1 XI0_I1612_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1612_MP16 (XI0_I1612_con I0_cm5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1612_MP15 (VDD I0_cm4_1 XI0_I1612_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1612_MP18 (VDD XI0_I1612_con I0_ha251_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1612_MP4 (XI0_I1612_xbn I0_cm5_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1614_MP9 (XI0_I1614_xp1 I0_fa138_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1614_MP11 (I0_ha253_0 XI0_I1614_xan XI0_I1614_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1614_MP12 (XI0_I1614_xp1 XI0_I1614_xbn I0_ha253_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1614_MP10 (VDD I0_fa139_0 XI0_I1614_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1614_MP2 (VDD I0_fa138_1 XI0_I1614_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1614_MP16 (XI0_I1614_con I0_fa139_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1614_MP15 (VDD I0_fa138_1 XI0_I1614_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1614_MP18 (VDD XI0_I1614_con I0_ha253_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1614_MP4 (XI0_I1614_xbn I0_fa139_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1616_MP9 (XI0_I1616_xp1 I0_fa140_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1616_MP11 (I0_ha255_0 XI0_I1616_xan XI0_I1616_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1616_MP12 (XI0_I1616_xp1 XI0_I1616_xbn I0_ha255_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1616_MP10 (VDD I0_cm141_0 XI0_I1616_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1616_MP2 (VDD I0_fa140_1 XI0_I1616_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1616_MP16 (XI0_I1616_con I0_cm141_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1616_MP15 (VDD I0_fa140_1 XI0_I1616_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1616_MP18 (VDD XI0_I1616_con I0_ha255_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1616_MP4 (XI0_I1616_xbn I0_cm141_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1618_MP9 (XI0_I1618_xp1 I0_cm142_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1618_MP11 (I0_ha257_0 XI0_I1618_xan XI0_I1618_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1618_MP12 (XI0_I1618_xp1 XI0_I1618_xbn I0_ha257_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1618_MP10 (VDD I0_cm143_0 XI0_I1618_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1618_MP2 (VDD I0_cm142_1 XI0_I1618_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1618_MP16 (XI0_I1618_con I0_cm143_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1618_MP15 (VDD I0_cm142_1 XI0_I1618_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1618_MP18 (VDD XI0_I1618_con I0_ha257_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1618_MP4 (XI0_I1618_xbn I0_cm143_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1622_MP9 (XI0_I1622_xp1 I0_fa210_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1622_MP11 (I0_ha261_0 XI0_I1622_xan XI0_I1622_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1622_MP12 (XI0_I1622_xp1 XI0_I1622_xbn I0_ha261_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1622_MP10 (VDD I0_fa211_0 XI0_I1622_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1622_MP2 (VDD I0_fa210_1 XI0_I1622_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1622_MP16 (XI0_I1622_con I0_fa211_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1622_MP15 (VDD I0_fa210_1 XI0_I1622_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1622_MP18 (VDD XI0_I1622_con I0_ha261_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1622_MP4 (XI0_I1622_xbn I0_fa211_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1623_MP9 (XI0_I1623_xp1 I0_fa211_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1623_MP11 (I0_ha262_0 XI0_I1623_xan XI0_I1623_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1623_MP12 (XI0_I1623_xp1 XI0_I1623_xbn I0_ha262_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1623_MP10 (VDD I0_fa212_0 XI0_I1623_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1623_MP2 (VDD I0_fa211_1 XI0_I1623_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1623_MP16 (XI0_I1623_con I0_fa212_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1623_MP15 (VDD I0_fa211_1 XI0_I1623_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1623_MP18 (VDD XI0_I1623_con I0_ha262_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1623_MP4 (XI0_I1623_xbn I0_fa212_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1627_MP9 (XI0_I1627_xp1 I0_cm215_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1627_MP11 (I0_ha266_0 XI0_I1627_xan XI0_I1627_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1627_MP12 (XI0_I1627_xp1 XI0_I1627_xbn I0_ha266_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1627_MP10 (VDD I0_cm216_0 XI0_I1627_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1627_MP2 (VDD I0_cm215_1 XI0_I1627_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1627_MP16 (XI0_I1627_con I0_cm216_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1627_MP15 (VDD I0_cm215_1 XI0_I1627_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1627_MP18 (VDD XI0_I1627_con I0_ha266_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1627_MP4 (XI0_I1627_xbn I0_cm216_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1611_MP9 (XI0_I1611_xp1 I0_fa3_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1611_MP11 (I0_ha250_0 XI0_I1611_xan XI0_I1611_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1611_MP12 (XI0_I1611_xp1 XI0_I1611_xbn I0_ha250_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1611_MP10 (VDD I0_cm4_0 XI0_I1611_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1611_MP2 (VDD I0_fa3_1 XI0_I1611_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1611_MP16 (XI0_I1611_con I0_cm4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1611_MP15 (VDD I0_fa3_1 XI0_I1611_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1611_MP18 (VDD XI0_I1611_con I0_ha250_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1611_MP4 (XI0_I1611_xbn I0_cm4_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1621_MP9 (XI0_I1621_xp1 I0_fa210_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1621_MP11 (I0_ha260_0 XI0_I1621_xan XI0_I1621_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1621_MP12 (XI0_I1621_xp1 XI0_I1621_xbn I0_ha260_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1621_MP10 (VDD I0_B_17_b3_5 XI0_I1621_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1621_MP2 (VDD I0_fa210_0 XI0_I1621_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1621_MP16 (XI0_I1621_con I0_B_17_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1621_MP15 (VDD I0_fa210_0 XI0_I1621_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1621_MP18 (VDD XI0_I1621_con I0_ha260_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1621_MP4 (XI0_I1621_xbn I0_B_17_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1626_MP9 (XI0_I1626_xp1 I0_cm214_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1626_MP11 (I0_ha265_0 XI0_I1626_xan XI0_I1626_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1626_MP12 (XI0_I1626_xp1 XI0_I1626_xbn I0_ha265_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1626_MP10 (VDD I0_cm215_0 XI0_I1626_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1626_MP2 (VDD I0_cm214_1 XI0_I1626_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1626_MP16 (XI0_I1626_con I0_cm215_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1626_MP15 (VDD I0_cm214_1 XI0_I1626_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1626_MP18 (VDD XI0_I1626_con I0_ha265_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1626_MP4 (XI0_I1626_xbn I0_cm215_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1624_MP9 (XI0_I1624_xp1 I0_fa212_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1624_MP11 (I0_ha263_0 XI0_I1624_xan XI0_I1624_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1624_MP12 (XI0_I1624_xp1 XI0_I1624_xbn I0_ha263_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1624_MP10 (VDD I0_fa213_0 XI0_I1624_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1624_MP2 (VDD I0_fa212_1 XI0_I1624_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1624_MP16 (XI0_I1624_con I0_fa213_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1624_MP15 (VDD I0_fa212_1 XI0_I1624_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1624_MP18 (VDD XI0_I1624_con I0_ha263_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1624_MP4 (XI0_I1624_xbn I0_fa213_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1625_MP9 (XI0_I1625_xp1 I0_fa213_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1625_MP11 (I0_ha264_0 XI0_I1625_xan XI0_I1625_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1625_MP12 (XI0_I1625_xp1 XI0_I1625_xbn I0_ha264_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1625_MP10 (VDD I0_cm214_0 XI0_I1625_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1625_MP2 (VDD I0_fa213_1 XI0_I1625_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1625_MP16 (XI0_I1625_con I0_cm214_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1625_MP15 (VDD I0_fa213_1 XI0_I1625_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1625_MP18 (VDD XI0_I1625_con I0_ha264_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1625_MP4 (XI0_I1625_xbn I0_cm214_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1628_MP9 (XI0_I1628_xp1 I0_cm216_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1628_MP11 (I0_ha267_0 XI0_I1628_xan XI0_I1628_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1628_MP12 (XI0_I1628_xp1 XI0_I1628_xbn I0_ha267_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1628_MP10 (VDD I0_cm217_0 XI0_I1628_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1628_MP2 (VDD I0_cm216_1 XI0_I1628_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1628_MP16 (XI0_I1628_con I0_cm217_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1628_MP15 (VDD I0_cm216_1 XI0_I1628_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1628_MP18 (VDD XI0_I1628_con I0_ha267_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1628_MP4 (XI0_I1628_xbn I0_cm217_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1629_MP9 (XI0_I1629_xp1 I0_cm217_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1629_MP11 (I0_ha268_0 XI0_I1629_xan XI0_I1629_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1629_MP12 (XI0_I1629_xp1 XI0_I1629_xbn I0_ha268_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1629_MP10 (VDD I0_cm218_0 XI0_I1629_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1629_MP2 (VDD I0_cm217_1 XI0_I1629_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1629_MP16 (XI0_I1629_con I0_cm218_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1629_MP15 (VDD I0_cm217_1 XI0_I1629_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1629_MP18 (VDD XI0_I1629_con I0_ha268_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1629_MP4 (XI0_I1629_xbn I0_cm218_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1630_MP9 (XI0_I1630_xp1 I0_cm218_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1630_MP11 (I0_ha269_0 XI0_I1630_xan XI0_I1630_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1630_MP12 (XI0_I1630_xp1 XI0_I1630_xbn I0_ha269_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1630_MP10 (VDD I0_cm219_0 XI0_I1630_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1630_MP2 (VDD I0_cm218_1 XI0_I1630_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1630_MP16 (XI0_I1630_con I0_cm219_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1630_MP15 (VDD I0_cm218_1 XI0_I1630_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1630_MP18 (VDD XI0_I1630_con I0_ha269_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1630_MP4 (XI0_I1630_xbn I0_cm219_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1631_MP9 (XI0_I1631_xp1 I0_cm219_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1631_MP11 (I0_ha270_0 XI0_I1631_xan XI0_I1631_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1631_MP12 (XI0_I1631_xp1 XI0_I1631_xbn I0_ha270_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1631_MP10 (VDD I0_cm220_0 XI0_I1631_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1631_MP2 (VDD I0_cm219_1 XI0_I1631_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1631_MP16 (XI0_I1631_con I0_cm220_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1631_MP15 (VDD I0_cm219_1 XI0_I1631_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1631_MP18 (VDD XI0_I1631_con I0_ha270_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1631_MP4 (XI0_I1631_xbn I0_cm220_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1633_MP9 (XI0_I1633_xp1 I0_cm221_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1633_MP11 (I0_ha272_0 XI0_I1633_xan XI0_I1633_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1633_MP12 (XI0_I1633_xp1 XI0_I1633_xbn I0_ha272_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1633_MP10 (VDD I0_cm222_0 XI0_I1633_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1633_MP2 (VDD I0_cm221_1 XI0_I1633_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1633_MP16 (XI0_I1633_con I0_cm222_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1633_MP15 (VDD I0_cm221_1 XI0_I1633_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1633_MP18 (VDD XI0_I1633_con I0_ha272_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1633_MP4 (XI0_I1633_xbn I0_cm222_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1632_MP9 (XI0_I1632_xp1 I0_cm220_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1632_MP11 (I0_ha271_0 XI0_I1632_xan XI0_I1632_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1632_MP12 (XI0_I1632_xp1 XI0_I1632_xbn I0_ha271_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1632_MP10 (VDD I0_cm221_0 XI0_I1632_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1632_MP2 (VDD I0_cm220_1 XI0_I1632_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1632_MP16 (XI0_I1632_con I0_cm221_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1632_MP15 (VDD I0_cm220_1 XI0_I1632_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1632_MP18 (VDD XI0_I1632_con I0_ha271_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1632_MP4 (XI0_I1632_xbn I0_cm221_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1634_MP9 (XI0_I1634_xp1 I0_cm222_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1634_MP11 (I0_ha273_0 XI0_I1634_xan XI0_I1634_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1634_MP12 (XI0_I1634_xp1 XI0_I1634_xbn I0_ha273_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1634_MP10 (VDD I0_cm223_0 XI0_I1634_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1634_MP2 (VDD I0_cm222_1 XI0_I1634_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1634_MP16 (XI0_I1634_con I0_cm223_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1634_MP15 (VDD I0_cm222_1 XI0_I1634_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1634_MP18 (VDD XI0_I1634_con I0_ha273_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1634_MP4 (XI0_I1634_xbn I0_cm223_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1635_MP9 (XI0_I1635_xp1 I0_cm223_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1635_MP11 (I0_ha274_0 XI0_I1635_xan XI0_I1635_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1635_MP12 (XI0_I1635_xp1 XI0_I1635_xbn I0_ha274_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1635_MP10 (VDD I0_cm224_0 XI0_I1635_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1635_MP2 (VDD I0_cm223_1 XI0_I1635_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1635_MP16 (XI0_I1635_con I0_cm224_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1635_MP15 (VDD I0_cm223_1 XI0_I1635_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1635_MP18 (VDD XI0_I1635_con I0_ha274_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1635_MP4 (XI0_I1635_xbn I0_cm224_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1637_MP9 (XI0_I1637_xp1 I0_cm225_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1637_MP11 (I0_ha276_0 XI0_I1637_xan XI0_I1637_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1637_MP12 (XI0_I1637_xp1 XI0_I1637_xbn I0_ha276_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1637_MP10 (VDD I0_cm226_0 XI0_I1637_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1637_MP2 (VDD I0_cm225_1 XI0_I1637_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1637_MP16 (XI0_I1637_con I0_cm226_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1637_MP15 (VDD I0_cm225_1 XI0_I1637_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1637_MP18 (VDD XI0_I1637_con I0_ha276_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1637_MP4 (XI0_I1637_xbn I0_cm226_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1636_MP9 (XI0_I1636_xp1 I0_cm224_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1636_MP11 (I0_ha275_0 XI0_I1636_xan XI0_I1636_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1636_MP12 (XI0_I1636_xp1 XI0_I1636_xbn I0_ha275_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1636_MP10 (VDD I0_cm225_0 XI0_I1636_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1636_MP2 (VDD I0_cm224_1 XI0_I1636_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1636_MP16 (XI0_I1636_con I0_cm225_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1636_MP15 (VDD I0_cm224_1 XI0_I1636_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1636_MP18 (VDD XI0_I1636_con I0_ha275_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1636_MP4 (XI0_I1636_xbn I0_cm225_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1638_MP9 (XI0_I1638_xp1 I0_cm226_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1638_MP11 (I0_ha277_0 XI0_I1638_xan XI0_I1638_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1638_MP12 (XI0_I1638_xp1 XI0_I1638_xbn I0_ha277_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1638_MP10 (VDD I0_cm227_0 XI0_I1638_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1638_MP2 (VDD I0_cm226_1 XI0_I1638_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1638_MP16 (XI0_I1638_con I0_cm227_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1638_MP15 (VDD I0_cm226_1 XI0_I1638_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1638_MP18 (VDD XI0_I1638_con I0_ha277_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1638_MP4 (XI0_I1638_xbn I0_cm227_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1639_MP9 (XI0_I1639_xp1 I0_cm227_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1639_MP11 (I0_ha278_0 XI0_I1639_xan XI0_I1639_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1639_MP12 (XI0_I1639_xp1 XI0_I1639_xbn I0_ha278_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1639_MP10 (VDD I0_cm228_0 XI0_I1639_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1639_MP2 (VDD I0_cm227_1 XI0_I1639_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1639_MP16 (XI0_I1639_con I0_cm228_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1639_MP15 (VDD I0_cm227_1 XI0_I1639_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1639_MP18 (VDD XI0_I1639_con I0_ha278_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1639_MP4 (XI0_I1639_xbn I0_cm228_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1640_MP9 (XI0_I1640_xp1 I0_cm228_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1640_MP11 (I0_ha279_0 XI0_I1640_xan XI0_I1640_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1640_MP12 (XI0_I1640_xp1 XI0_I1640_xbn I0_ha279_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1640_MP10 (VDD I0_cm229_0 XI0_I1640_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1640_MP2 (VDD I0_cm228_1 XI0_I1640_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1640_MP16 (XI0_I1640_con I0_cm229_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1640_MP15 (VDD I0_cm228_1 XI0_I1640_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1640_MP18 (VDD XI0_I1640_con I0_ha279_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1640_MP4 (XI0_I1640_xbn I0_cm229_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1643_MP9 (XI0_I1643_xp1 I0_cm231_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1643_MP11 (I0_ha282_0 XI0_I1643_xan XI0_I1643_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1643_MP12 (XI0_I1643_xp1 XI0_I1643_xbn I0_ha282_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1643_MP10 (VDD I0_cm232_0 XI0_I1643_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1643_MP2 (VDD I0_cm231_1 XI0_I1643_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1643_MP16 (XI0_I1643_con I0_cm232_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1643_MP15 (VDD I0_cm231_1 XI0_I1643_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1643_MP18 (VDD XI0_I1643_con I0_ha282_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1643_MP4 (XI0_I1643_xbn I0_cm232_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1645_MP9 (XI0_I1645_xp1 I0_cm233_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1645_MP11 (I0_ha284_0 XI0_I1645_xan XI0_I1645_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1645_MP12 (XI0_I1645_xp1 XI0_I1645_xbn I0_ha284_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1645_MP10 (VDD I0_cm234_0 XI0_I1645_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1645_MP2 (VDD I0_cm233_1 XI0_I1645_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1645_MP16 (XI0_I1645_con I0_cm234_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1645_MP15 (VDD I0_cm233_1 XI0_I1645_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1645_MP18 (VDD XI0_I1645_con I0_ha284_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1645_MP4 (XI0_I1645_xbn I0_cm234_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1647_MP9 (XI0_I1647_xp1 I0_cm235_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1647_MP11 (I0_ha286_0 XI0_I1647_xan XI0_I1647_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1647_MP12 (XI0_I1647_xp1 XI0_I1647_xbn I0_ha286_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1647_MP10 (VDD I0_cm236_0 XI0_I1647_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1647_MP2 (VDD I0_cm235_1 XI0_I1647_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1647_MP16 (XI0_I1647_con I0_cm236_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1647_MP15 (VDD I0_cm235_1 XI0_I1647_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1647_MP18 (VDD XI0_I1647_con I0_ha286_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1647_MP4 (XI0_I1647_xbn I0_cm236_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1649_MP9 (XI0_I1649_xp1 I0_fa237_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1649_MP11 (I0_ha288_0 XI0_I1649_xan XI0_I1649_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1649_MP12 (XI0_I1649_xp1 XI0_I1649_xbn I0_ha288_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1649_MP10 (VDD I0_cm238_0 XI0_I1649_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1649_MP2 (VDD I0_fa237_1 XI0_I1649_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1649_MP16 (XI0_I1649_con I0_cm238_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1649_MP15 (VDD I0_fa237_1 XI0_I1649_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1649_MP18 (VDD XI0_I1649_con I0_ha288_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1649_MP4 (XI0_I1649_xbn I0_cm238_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1651_MP9 (XI0_I1651_xp1 I0_fa239_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1651_MP11 (I0_ha290_0 XI0_I1651_xan XI0_I1651_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1651_MP12 (XI0_I1651_xp1 XI0_I1651_xbn I0_ha290_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1651_MP10 (VDD I0_cm240_0 XI0_I1651_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1651_MP2 (VDD I0_fa239_1 XI0_I1651_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1651_MP16 (XI0_I1651_con I0_cm240_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1651_MP15 (VDD I0_fa239_1 XI0_I1651_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1651_MP18 (VDD XI0_I1651_con I0_ha290_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1651_MP4 (XI0_I1651_xbn I0_cm240_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1653_MP9 (XI0_I1653_xp1 I0_fa241_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1653_MP11 (I0_ha292_0 XI0_I1653_xan XI0_I1653_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1653_MP12 (XI0_I1653_xp1 XI0_I1653_xbn I0_ha292_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1653_MP10 (VDD I0_fa242_0 XI0_I1653_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1653_MP2 (VDD I0_fa241_1 XI0_I1653_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1653_MP16 (XI0_I1653_con I0_fa242_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1653_MP15 (VDD I0_fa241_1 XI0_I1653_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1653_MP18 (VDD XI0_I1653_con I0_ha292_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1653_MP4 (XI0_I1653_xbn I0_fa242_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1655_MP9 (XI0_I1655_xp1 I0_cm199_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1655_MP11 (I0_ha294_0 XI0_I1655_xan XI0_I1655_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1655_MP12 (XI0_I1655_xp1 XI0_I1655_xbn I0_ha294_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI0_I1655_MP10 (VDD I0_cm200_0 XI0_I1655_xp1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1655_MP2 (VDD I0_cm199_1 XI0_I1655_xan VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI0_I1655_MP16 (XI0_I1655_con I0_cm200_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0528p pd=0.68u ps=0.68u
    I_MXI0_I1655_MP15 (VDD I0_cm199_1 XI0_I1655_con VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI0_I1655_MP18 (VDD XI0_I1655_con I0_ha294_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI0_I1655_MP4 (XI0_I1655_xbn I0_cm200_0 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I127_XG_MP2 (XI1_I1344_I127_XG_p1 I1_I1344_G31_30 I1_I1344_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I127_XG_MP0 (VDD I1_I1344_P31_30 XI1_I1344_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I127_XG_MP1 (XI1_I1344_I127_XG_p1 I1_I1344_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I182_XG_MP2 (XI1_I1344_I182_XG_p1 I1_I1344_G31_24 I1_I1344_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I182_XG_MP0 (VDD I1_I1344_P31_24 XI1_I1344_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I182_XG_MP1 (XI1_I1344_I182_XG_p1 I1_I1344_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I182_XG_MP2 (XI1_I1298_I182_XG_p1 I1_I1298_G31_24 I1_I1298_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I182_XG_MP0 (VDD I1_I1298_P31_24 XI1_I1298_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I182_XG_MP1 (XI1_I1298_I182_XG_p1 I1_I1298_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I125_XG_MP2 (XI1_I1298_I125_XG_p1 I1_I1298_G29_28 I1_I1298_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I125_XG_MP0 (VDD I1_I1298_P29_28 XI1_I1298_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I125_XG_MP1 (XI1_I1298_I125_XG_p1 I1_I1298_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I127_XG_MP2 (XI1_I1298_I127_XG_p1 I1_I1298_G31_30 I1_I1298_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I127_XG_MP0 (VDD I1_I1298_P31_30 XI1_I1298_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I127_XG_MP1 (XI1_I1298_I127_XG_p1 I1_I1298_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I126_XG_MP2 (XI1_I1298_I126_XG_p1 I1_I1298_G30_29 I1_I1298_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I126_XG_MP0 (VDD I1_I1298_P30_29 XI1_I1298_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I126_XG_MP1 (XI1_I1298_I126_XG_p1 I1_I1298_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I126_XG_MP2 (XI1_I1252_I126_XG_p1 I1_I1252_G30_29 I1_I1252_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I126_XG_MP0 (VDD I1_I1252_P30_29 XI1_I1252_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I126_XG_MP1 (XI1_I1252_I126_XG_p1 I1_I1252_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I125_XG_MP2 (XI1_I1252_I125_XG_p1 I1_I1252_G29_28 I1_I1252_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I125_XG_MP0 (VDD I1_I1252_P29_28 XI1_I1252_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I125_XG_MP1 (XI1_I1252_I125_XG_p1 I1_I1252_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I127_XG_MP2 (XI1_I1252_I127_XG_p1 I1_I1252_G31_30 I1_I1252_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I127_XG_MP0 (VDD I1_I1252_P31_30 XI1_I1252_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I127_XG_MP1 (XI1_I1252_I127_XG_p1 I1_I1252_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I125_XG_MP2 (XI1_I838_I125_XG_p1 I1_I838_G29_28 I1_I838_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I125_XG_MP0 (VDD I1_I838_P29_28 XI1_I838_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I125_XG_MP1 (XI1_I838_I125_XG_p1 I1_I838_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I127_XG_MP2 (XI1_I838_I127_XG_p1 I1_I838_G31_30 I1_I838_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I127_XG_MP0 (VDD I1_I838_P31_30 XI1_I838_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I127_XG_MP1 (XI1_I838_I127_XG_p1 I1_I838_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I123_XG_MP2 (XI1_I838_I123_XG_p1 I1_I838_G27_26 I1_I838_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I123_XG_MP0 (VDD I1_I838_P27_26 XI1_I838_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I123_XG_MP1 (XI1_I838_I123_XG_p1 I1_I838_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I180_XG_MP2 (XI1_I838_I180_XG_p1 I1_I838_G29_22 I1_I838_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I180_XG_MP0 (VDD I1_I838_P29_22 XI1_I838_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I180_XG_MP1 (XI1_I838_I180_XG_p1 I1_I838_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I178_XG_MP2 (XI1_I838_I178_XG_p1 I1_I838_G27_20 I1_I838_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I178_XG_MP0 (VDD I1_I838_P27_20 XI1_I838_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I178_XG_MP1 (XI1_I838_I178_XG_p1 I1_I838_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I182_XG_MP2 (XI1_I838_I182_XG_p1 I1_I838_G31_24 I1_I838_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I182_XG_MP0 (VDD I1_I838_P31_24 XI1_I838_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I182_XG_MP1 (XI1_I838_I182_XG_p1 I1_I838_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I174_XG_MP2 (XI1_I838_I174_XG_p1 I1_I838_G23_16 I1_I838_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I174_XG_MP0 (VDD I1_I838_P23_16 XI1_I838_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I174_XG_MP1 (XI1_I838_I174_XG_p1 I1_I838_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I166_XG_MP2 (XI1_I838_I166_XG_p1 I1_I838_G15_8 I1_I838_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I166_XG_MP0 (VDD I1_I838_P15_8 XI1_I838_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I166_XG_MP1 (XI1_I838_I166_XG_p1 I1_I838_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I170_XG_MP2 (XI1_I838_I170_XG_p1 I1_I838_G19_12 I1_I838_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I170_XG_MP0 (VDD I1_I838_P19_12 XI1_I838_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I170_XG_MP1 (XI1_I838_I170_XG_p1 I1_I838_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I162_XG_MP2 (XI1_I838_I162_XG_p1 I1_I838_G11_4 I1_I838_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I162_XG_MP0 (VDD I1_I838_P11_4 XI1_I838_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I162_XG_MP1 (XI1_I838_I162_XG_p1 I1_I838_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I180_XG_MP2 (XI1_I792_I180_XG_p1 I1_I792_G29_22 I1_I792_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I180_XG_MP0 (VDD I1_I792_P29_22 XI1_I792_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I180_XG_MP1 (XI1_I792_I180_XG_p1 I1_I792_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I178_XG_MP2 (XI1_I792_I178_XG_p1 I1_I792_G27_20 I1_I792_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I178_XG_MP0 (VDD I1_I792_P27_20 XI1_I792_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I178_XG_MP1 (XI1_I792_I178_XG_p1 I1_I792_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I182_XG_MP2 (XI1_I792_I182_XG_p1 I1_I792_G31_24 I1_I792_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I182_XG_MP0 (VDD I1_I792_P31_24 XI1_I792_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I182_XG_MP1 (XI1_I792_I182_XG_p1 I1_I792_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I123_XG_MP2 (XI1_I792_I123_XG_p1 I1_I792_G27_26 I1_I792_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I123_XG_MP0 (VDD I1_I792_P27_26 XI1_I792_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I123_XG_MP1 (XI1_I792_I123_XG_p1 I1_I792_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I125_XG_MP2 (XI1_I792_I125_XG_p1 I1_I792_G29_28 I1_I792_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I125_XG_MP0 (VDD I1_I792_P29_28 XI1_I792_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I125_XG_MP1 (XI1_I792_I125_XG_p1 I1_I792_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I127_XG_MP2 (XI1_I792_I127_XG_p1 I1_I792_G31_30 I1_I792_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I127_XG_MP0 (VDD I1_I792_P31_30 XI1_I792_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I127_XG_MP1 (XI1_I792_I127_XG_p1 I1_I792_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I181_XG_MP2 (XI1_I792_I181_XG_p1 I1_I792_G30_23 I1_I792_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I181_XG_MP0 (VDD I1_I792_P30_23 XI1_I792_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I181_XG_MP1 (XI1_I792_I181_XG_p1 I1_I792_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I124_XG_MP2 (XI1_I792_I124_XG_p1 I1_I792_G28_27 I1_I792_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I124_XG_MP0 (VDD I1_I792_P28_27 XI1_I792_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I124_XG_MP1 (XI1_I792_I124_XG_p1 I1_I792_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I126_XG_MP2 (XI1_I792_I126_XG_p1 I1_I792_G30_29 I1_I792_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I126_XG_MP0 (VDD I1_I792_P30_29 XI1_I792_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I126_XG_MP1 (XI1_I792_I126_XG_p1 I1_I792_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I125_XG_MP2 (XI1_I1344_I125_XG_p1 I1_I1344_G29_28 I1_I1344_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I125_XG_MP0 (VDD I1_I1344_P29_28 XI1_I1344_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I125_XG_MP1 (XI1_I1344_I125_XG_p1 I1_I1344_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I178_XG_MP2 (XI1_I1344_I178_XG_p1 I1_I1344_G27_20 I1_I1344_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I178_XG_MP0 (VDD I1_I1344_P27_20 XI1_I1344_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I178_XG_MP1 (XI1_I1344_I178_XG_p1 I1_I1344_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I174_XG_MP2 (XI1_I1344_I174_XG_p1 I1_I1344_G23_16 I1_I1344_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I174_XG_MP0 (VDD I1_I1344_P23_16 XI1_I1344_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I174_XG_MP1 (XI1_I1344_I174_XG_p1 I1_I1344_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I178_XG_MP2 (XI1_I1298_I178_XG_p1 I1_I1298_G27_20 I1_I1298_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I178_XG_MP0 (VDD I1_I1298_P27_20 XI1_I1298_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I178_XG_MP1 (XI1_I1298_I178_XG_p1 I1_I1298_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I123_XG_MP2 (XI1_I1298_I123_XG_p1 I1_I1298_G27_26 I1_I1298_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I123_XG_MP0 (VDD I1_I1298_P27_26 XI1_I1298_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I123_XG_MP1 (XI1_I1298_I123_XG_p1 I1_I1298_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I124_XG_MP2 (XI1_I1298_I124_XG_p1 I1_I1298_G28_27 I1_I1298_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I124_XG_MP0 (VDD I1_I1298_P28_27 XI1_I1298_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I124_XG_MP1 (XI1_I1298_I124_XG_p1 I1_I1298_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I181_XG_MP2 (XI1_I1252_I181_XG_p1 I1_I1252_G30_23 I1_I1252_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I181_XG_MP0 (VDD I1_I1252_P30_23 XI1_I1252_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I181_XG_MP1 (XI1_I1252_I181_XG_p1 I1_I1252_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I124_XG_MP2 (XI1_I1252_I124_XG_p1 I1_I1252_G28_27 I1_I1252_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I124_XG_MP0 (VDD I1_I1252_P28_27 XI1_I1252_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I124_XG_MP1 (XI1_I1252_I124_XG_p1 I1_I1252_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I182_XG_MP2 (XI1_I1252_I182_XG_p1 I1_I1252_G31_24 I1_I1252_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I182_XG_MP0 (VDD I1_I1252_P31_24 XI1_I1252_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I182_XG_MP1 (XI1_I1252_I182_XG_p1 I1_I1252_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I123_XG_MP2 (XI1_I1252_I123_XG_p1 I1_I1252_G27_26 I1_I1252_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I123_XG_MP0 (VDD I1_I1252_P27_26 XI1_I1252_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I123_XG_MP1 (XI1_I1252_I123_XG_p1 I1_I1252_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I127_XG_MP2 (XI1_I1206_I127_XG_p1 I1_I1206_G31_30 I1_I1206_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I127_XG_MP0 (VDD I1_I1206_P31_30 XI1_I1206_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I127_XG_MP1 (XI1_I1206_I127_XG_p1 I1_I1206_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I125_XG_MP2 (XI1_I1206_I125_XG_p1 I1_I1206_G29_28 I1_I1206_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I125_XG_MP0 (VDD I1_I1206_P29_28 XI1_I1206_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I125_XG_MP1 (XI1_I1206_I125_XG_p1 I1_I1206_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I126_XG_MP2 (XI1_I1206_I126_XG_p1 I1_I1206_G30_29 I1_I1206_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I126_XG_MP0 (VDD I1_I1206_P30_29 XI1_I1206_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I126_XG_MP1 (XI1_I1206_I126_XG_p1 I1_I1206_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I124_XG_MP2 (XI1_I1206_I124_XG_p1 I1_I1206_G28_27 I1_I1206_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I124_XG_MP0 (VDD I1_I1206_P28_27 XI1_I1206_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I124_XG_MP1 (XI1_I1206_I124_XG_p1 I1_I1206_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I121_XG_MP2 (XI1_I838_I121_XG_p1 I1_I838_G25_24 I1_I838_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I121_XG_MP0 (VDD I1_I838_P25_24 XI1_I838_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I121_XG_MP1 (XI1_I838_I121_XG_p1 I1_I838_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I119_XG_MP2 (XI1_I838_I119_XG_p1 I1_I838_G23_22 I1_I838_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I119_XG_MP0 (VDD I1_I838_P23_22 XI1_I838_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I119_XG_MP1 (XI1_I838_I119_XG_p1 I1_I838_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I113_XG_MP2 (XI1_I838_I113_XG_p1 I1_I838_G17_16 I1_I838_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I113_XG_MP0 (VDD I1_I838_P17_16 XI1_I838_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I113_XG_MP1 (XI1_I838_I113_XG_p1 I1_I838_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I111_XG_MP2 (XI1_I838_I111_XG_p1 I1_I838_G15_14 I1_I838_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I111_XG_MP0 (VDD I1_I838_P15_14 XI1_I838_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I111_XG_MP1 (XI1_I838_I111_XG_p1 I1_I838_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I176_XG_MP2 (XI1_I838_I176_XG_p1 I1_I838_G25_18 I1_I838_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I176_XG_MP0 (VDD I1_I838_P25_18 XI1_I838_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I176_XG_MP1 (XI1_I838_I176_XG_p1 I1_I838_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I172_XG_MP2 (XI1_I838_I172_XG_p1 I1_I838_G21_14 I1_I838_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I172_XG_MP0 (VDD I1_I838_P21_14 XI1_I838_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I172_XG_MP1 (XI1_I838_I172_XG_p1 I1_I838_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I164_XG_MP2 (XI1_I838_I164_XG_p1 I1_I838_G13_6 I1_I838_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I164_XG_MP0 (VDD I1_I838_P13_6 XI1_I838_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I164_XG_MP1 (XI1_I838_I164_XG_p1 I1_I838_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I168_XG_MP2 (XI1_I838_I168_XG_p1 I1_I838_G17_10 I1_I838_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I168_XG_MP0 (VDD I1_I838_P17_10 XI1_I838_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I168_XG_MP1 (XI1_I838_I168_XG_p1 I1_I838_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I176_XG_MP2 (XI1_I792_I176_XG_p1 I1_I792_G25_18 I1_I792_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I176_XG_MP0 (VDD I1_I792_P25_18 XI1_I792_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I176_XG_MP1 (XI1_I792_I176_XG_p1 I1_I792_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I174_XG_MP2 (XI1_I792_I174_XG_p1 I1_I792_G23_16 I1_I792_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I174_XG_MP0 (VDD I1_I792_P23_16 XI1_I792_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I174_XG_MP1 (XI1_I792_I174_XG_p1 I1_I792_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I119_XG_MP2 (XI1_I792_I119_XG_p1 I1_I792_G23_22 I1_I792_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I119_XG_MP0 (VDD I1_I792_P23_22 XI1_I792_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I119_XG_MP1 (XI1_I792_I119_XG_p1 I1_I792_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I121_XG_MP2 (XI1_I792_I121_XG_p1 I1_I792_G25_24 I1_I792_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I121_XG_MP0 (VDD I1_I792_P25_24 XI1_I792_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I121_XG_MP1 (XI1_I792_I121_XG_p1 I1_I792_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I173_XG_MP2 (XI1_I792_I173_XG_p1 I1_I792_G22_15 I1_I792_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I173_XG_MP0 (VDD I1_I792_P22_15 XI1_I792_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I173_XG_MP1 (XI1_I792_I173_XG_p1 I1_I792_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I179_XG_MP2 (XI1_I792_I179_XG_p1 I1_I792_G28_21 I1_I792_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I179_XG_MP0 (VDD I1_I792_P28_21 XI1_I792_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I179_XG_MP1 (XI1_I792_I179_XG_p1 I1_I792_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I122_XG_MP2 (XI1_I792_I122_XG_p1 I1_I792_G26_25 I1_I792_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I122_XG_MP0 (VDD I1_I792_P26_25 XI1_I792_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I122_XG_MP1 (XI1_I792_I122_XG_p1 I1_I792_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I126_XG_MP2 (XI1_I1344_I126_XG_p1 I1_I1344_G30_29 I1_I1344_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I126_XG_MP0 (VDD I1_I1344_P30_29 XI1_I1344_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I126_XG_MP1 (XI1_I1344_I126_XG_p1 I1_I1344_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I123_XG_MP2 (XI1_I1344_I123_XG_p1 I1_I1344_G27_26 I1_I1344_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I123_XG_MP0 (VDD I1_I1344_P27_26 XI1_I1344_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I123_XG_MP1 (XI1_I1344_I123_XG_p1 I1_I1344_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I121_XG_MP2 (XI1_I1344_I121_XG_p1 I1_I1344_G25_24 I1_I1344_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I121_XG_MP0 (VDD I1_I1344_P25_24 XI1_I1344_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I121_XG_MP1 (XI1_I1344_I121_XG_p1 I1_I1344_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I180_XG_MP2 (XI1_I1344_I180_XG_p1 I1_I1344_G29_22 I1_I1344_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I180_XG_MP0 (VDD I1_I1344_P29_22 XI1_I1344_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I180_XG_MP1 (XI1_I1344_I180_XG_p1 I1_I1344_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I166_XG_MP2 (XI1_I1344_I166_XG_p1 I1_I1344_G15_8 I1_I1344_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I166_XG_MP0 (VDD I1_I1344_P15_8 XI1_I1344_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I166_XG_MP1 (XI1_I1344_I166_XG_p1 I1_I1344_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I170_XG_MP2 (XI1_I1344_I170_XG_p1 I1_I1344_G19_12 I1_I1344_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I170_XG_MP0 (VDD I1_I1344_P19_12 XI1_I1344_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I170_XG_MP1 (XI1_I1344_I170_XG_p1 I1_I1344_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I162_XG_MP2 (XI1_I1344_I162_XG_p1 I1_I1344_G11_4 I1_I1344_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I162_XG_MP0 (VDD I1_I1344_P11_4 XI1_I1344_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I162_XG_MP1 (XI1_I1344_I162_XG_p1 I1_I1344_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I174_XG_MP2 (XI1_I1298_I174_XG_p1 I1_I1298_G23_16 I1_I1298_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I174_XG_MP0 (VDD I1_I1298_P23_16 XI1_I1298_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I174_XG_MP1 (XI1_I1298_I174_XG_p1 I1_I1298_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I180_XG_MP2 (XI1_I1298_I180_XG_p1 I1_I1298_G29_22 I1_I1298_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I180_XG_MP0 (VDD I1_I1298_P29_22 XI1_I1298_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I180_XG_MP1 (XI1_I1298_I180_XG_p1 I1_I1298_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I121_XG_MP2 (XI1_I1298_I121_XG_p1 I1_I1298_G25_24 I1_I1298_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I121_XG_MP0 (VDD I1_I1298_P25_24 XI1_I1298_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I121_XG_MP1 (XI1_I1298_I121_XG_p1 I1_I1298_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I181_XG_MP2 (XI1_I1298_I181_XG_p1 I1_I1298_G30_23 I1_I1298_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I181_XG_MP0 (VDD I1_I1298_P30_23 XI1_I1298_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I181_XG_MP1 (XI1_I1298_I181_XG_p1 I1_I1298_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I122_XG_MP2 (XI1_I1298_I122_XG_p1 I1_I1298_G26_25 I1_I1298_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I122_XG_MP0 (VDD I1_I1298_P26_25 XI1_I1298_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I122_XG_MP1 (XI1_I1298_I122_XG_p1 I1_I1298_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I179_XG_MP2 (XI1_I1252_I179_XG_p1 I1_I1252_G28_21 I1_I1252_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I179_XG_MP0 (VDD I1_I1252_P28_21 XI1_I1252_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I179_XG_MP1 (XI1_I1252_I179_XG_p1 I1_I1252_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I122_XG_MP2 (XI1_I1252_I122_XG_p1 I1_I1252_G26_25 I1_I1252_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I122_XG_MP0 (VDD I1_I1252_P26_25 XI1_I1252_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I122_XG_MP1 (XI1_I1252_I122_XG_p1 I1_I1252_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I120_XG_MP2 (XI1_I1252_I120_XG_p1 I1_I1252_G24_23 I1_I1252_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I120_XG_MP0 (VDD I1_I1252_P24_23 XI1_I1252_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I120_XG_MP1 (XI1_I1252_I120_XG_p1 I1_I1252_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I180_XG_MP2 (XI1_I1252_I180_XG_p1 I1_I1252_G29_22 I1_I1252_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I180_XG_MP0 (VDD I1_I1252_P29_22 XI1_I1252_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I180_XG_MP1 (XI1_I1252_I180_XG_p1 I1_I1252_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I121_XG_MP2 (XI1_I1252_I121_XG_p1 I1_I1252_G25_24 I1_I1252_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I121_XG_MP0 (VDD I1_I1252_P25_24 XI1_I1252_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I121_XG_MP1 (XI1_I1252_I121_XG_p1 I1_I1252_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I123_XG_MP2 (XI1_I1206_I123_XG_p1 I1_I1206_G27_26 I1_I1206_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I123_XG_MP0 (VDD I1_I1206_P27_26 XI1_I1206_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I123_XG_MP1 (XI1_I1206_I123_XG_p1 I1_I1206_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I122_XG_MP2 (XI1_I1206_I122_XG_p1 I1_I1206_G26_25 I1_I1206_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I122_XG_MP0 (VDD I1_I1206_P26_25 XI1_I1206_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I122_XG_MP1 (XI1_I1206_I122_XG_p1 I1_I1206_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I109_XG_MP2 (XI1_I838_I109_XG_p1 I1_I838_G13_12 I1_I838_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I109_XG_MP0 (VDD I1_I838_P13_12 XI1_I838_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I109_XG_MP1 (XI1_I838_I109_XG_p1 I1_I838_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I158_XG_MP2 (XI1_I838_I158_XG_p1 I1_I838_G9_2 I1_I838_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I158_XG_MP0 (VDD I1_I838_P9_2 XI1_I838_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I158_XG_MP1 (XI1_I838_I158_XG_p1 I1_I838_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I172_XG_MP2 (XI1_I792_I172_XG_p1 I1_I792_G21_14 I1_I792_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I172_XG_MP0 (VDD I1_I792_P21_14 XI1_I792_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I172_XG_MP1 (XI1_I792_I172_XG_p1 I1_I792_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I170_XG_MP2 (XI1_I792_I170_XG_p1 I1_I792_G19_12 I1_I792_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I170_XG_MP0 (VDD I1_I792_P19_12 XI1_I792_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I170_XG_MP1 (XI1_I792_I170_XG_p1 I1_I792_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I166_XG_MP2 (XI1_I792_I166_XG_p1 I1_I792_G15_8 I1_I792_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I166_XG_MP0 (VDD I1_I792_P15_8 XI1_I792_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I166_XG_MP1 (XI1_I792_I166_XG_p1 I1_I792_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I115_XG_MP2 (XI1_I792_I115_XG_p1 I1_I792_G19_18 I1_I792_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I115_XG_MP0 (VDD I1_I792_P19_18 XI1_I792_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I115_XG_MP1 (XI1_I792_I115_XG_p1 I1_I792_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I117_XG_MP2 (XI1_I792_I117_XG_p1 I1_I792_G21_20 I1_I792_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I117_XG_MP0 (VDD I1_I792_P21_20 XI1_I792_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I117_XG_MP1 (XI1_I792_I117_XG_p1 I1_I792_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I177_XG_MP2 (XI1_I792_I177_XG_p1 I1_I792_G26_19 I1_I792_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I177_XG_MP0 (VDD I1_I792_P26_19 XI1_I792_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I177_XG_MP1 (XI1_I792_I177_XG_p1 I1_I792_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I118_XG_MP2 (XI1_I792_I118_XG_p1 I1_I792_G22_21 I1_I792_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I118_XG_MP0 (VDD I1_I792_P22_21 XI1_I792_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I118_XG_MP1 (XI1_I792_I118_XG_p1 I1_I792_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I120_XG_MP2 (XI1_I792_I120_XG_p1 I1_I792_G24_23 I1_I792_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I120_XG_MP0 (VDD I1_I792_P24_23 XI1_I792_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I120_XG_MP1 (XI1_I792_I120_XG_p1 I1_I792_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I119_XG_MP2 (XI1_I1344_I119_XG_p1 I1_I1344_G23_22 I1_I1344_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I119_XG_MP0 (VDD I1_I1344_P23_22 XI1_I1344_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I119_XG_MP1 (XI1_I1344_I119_XG_p1 I1_I1344_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I117_XG_MP2 (XI1_I1344_I117_XG_p1 I1_I1344_G21_20 I1_I1344_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I117_XG_MP0 (VDD I1_I1344_P21_20 XI1_I1344_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I117_XG_MP1 (XI1_I1344_I117_XG_p1 I1_I1344_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I176_XG_MP2 (XI1_I1344_I176_XG_p1 I1_I1344_G25_18 I1_I1344_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I176_XG_MP0 (VDD I1_I1344_P25_18 XI1_I1344_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I176_XG_MP1 (XI1_I1344_I176_XG_p1 I1_I1344_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I115_XG_MP2 (XI1_I1344_I115_XG_p1 I1_I1344_G19_18 I1_I1344_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I115_XG_MP0 (VDD I1_I1344_P19_18 XI1_I1344_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I115_XG_MP1 (XI1_I1344_I115_XG_p1 I1_I1344_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I113_XG_MP2 (XI1_I1344_I113_XG_p1 I1_I1344_G17_16 I1_I1344_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I113_XG_MP0 (VDD I1_I1344_P17_16 XI1_I1344_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I113_XG_MP1 (XI1_I1344_I113_XG_p1 I1_I1344_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I111_XG_MP2 (XI1_I1344_I111_XG_p1 I1_I1344_G15_14 I1_I1344_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I111_XG_MP0 (VDD I1_I1344_P15_14 XI1_I1344_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I111_XG_MP1 (XI1_I1344_I111_XG_p1 I1_I1344_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I176_XG_MP2 (XI1_I1298_I176_XG_p1 I1_I1298_G25_18 I1_I1298_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I176_XG_MP0 (VDD I1_I1298_P25_18 XI1_I1298_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I176_XG_MP1 (XI1_I1298_I176_XG_p1 I1_I1298_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I119_XG_MP2 (XI1_I1298_I119_XG_p1 I1_I1298_G23_22 I1_I1298_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I119_XG_MP0 (VDD I1_I1298_P23_22 XI1_I1298_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I119_XG_MP1 (XI1_I1298_I119_XG_p1 I1_I1298_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I179_XG_MP2 (XI1_I1298_I179_XG_p1 I1_I1298_G28_21 I1_I1298_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I179_XG_MP0 (VDD I1_I1298_P28_21 XI1_I1298_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I179_XG_MP1 (XI1_I1298_I179_XG_p1 I1_I1298_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I120_XG_MP2 (XI1_I1298_I120_XG_p1 I1_I1298_G24_23 I1_I1298_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I120_XG_MP0 (VDD I1_I1298_P24_23 XI1_I1298_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I120_XG_MP1 (XI1_I1298_I120_XG_p1 I1_I1298_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I177_XG_MP2 (XI1_I1252_I177_XG_p1 I1_I1252_G26_19 I1_I1252_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I177_XG_MP0 (VDD I1_I1252_P26_19 XI1_I1252_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I177_XG_MP1 (XI1_I1252_I177_XG_p1 I1_I1252_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I174_XG_MP2 (XI1_I1252_I174_XG_p1 I1_I1252_G23_16 I1_I1252_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I174_XG_MP0 (VDD I1_I1252_P23_16 XI1_I1252_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I174_XG_MP1 (XI1_I1252_I174_XG_p1 I1_I1252_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I119_XG_MP2 (XI1_I1252_I119_XG_p1 I1_I1252_G23_22 I1_I1252_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I119_XG_MP0 (VDD I1_I1252_P23_22 XI1_I1252_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I119_XG_MP1 (XI1_I1252_I119_XG_p1 I1_I1252_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I119_XG_MP2 (XI1_I1206_I119_XG_p1 I1_I1206_G23_22 I1_I1206_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I119_XG_MP0 (VDD I1_I1206_P23_22 XI1_I1206_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I119_XG_MP1 (XI1_I1206_I119_XG_p1 I1_I1206_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I121_XG_MP2 (XI1_I1206_I121_XG_p1 I1_I1206_G25_24 I1_I1206_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I121_XG_MP0 (VDD I1_I1206_P25_24 XI1_I1206_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I121_XG_MP1 (XI1_I1206_I121_XG_p1 I1_I1206_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I120_XG_MP2 (XI1_I1206_I120_XG_p1 I1_I1206_G24_23 I1_I1206_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I120_XG_MP0 (VDD I1_I1206_P24_23 XI1_I1206_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I120_XG_MP1 (XI1_I1206_I120_XG_p1 I1_I1206_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I181_XG_MP2 (XI1_I1206_I181_XG_p1 I1_I1206_G30_23 I1_I1206_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I181_XG_MP0 (VDD I1_I1206_P30_23 XI1_I1206_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I181_XG_MP1 (XI1_I1206_I181_XG_p1 I1_I1206_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I126_XG_MP2 (XI1_I838_I126_XG_p1 I1_I838_G30_29 I1_I838_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I126_XG_MP0 (VDD I1_I838_P30_29 XI1_I838_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I126_XG_MP1 (XI1_I838_I126_XG_p1 I1_I838_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I124_XG_MP2 (XI1_I838_I124_XG_p1 I1_I838_G28_27 I1_I838_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I124_XG_MP0 (VDD I1_I838_P28_27 XI1_I838_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I124_XG_MP1 (XI1_I838_I124_XG_p1 I1_I838_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I122_XG_MP2 (XI1_I838_I122_XG_p1 I1_I838_G26_25 I1_I838_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I122_XG_MP0 (VDD I1_I838_P26_25 XI1_I838_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I122_XG_MP1 (XI1_I838_I122_XG_p1 I1_I838_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I120_XG_MP2 (XI1_I838_I120_XG_p1 I1_I838_G24_23 I1_I838_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I120_XG_MP0 (VDD I1_I838_P24_23 XI1_I838_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I120_XG_MP1 (XI1_I838_I120_XG_p1 I1_I838_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I118_XG_MP2 (XI1_I838_I118_XG_p1 I1_I838_G22_21 I1_I838_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I118_XG_MP0 (VDD I1_I838_P22_21 XI1_I838_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I118_XG_MP1 (XI1_I838_I118_XG_p1 I1_I838_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I116_XG_MP2 (XI1_I838_I116_XG_p1 I1_I838_G20_19 I1_I838_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I116_XG_MP0 (VDD I1_I838_P20_19 XI1_I838_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I116_XG_MP1 (XI1_I838_I116_XG_p1 I1_I838_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I107_XG_MP2 (XI1_I838_I107_XG_p1 I1_I838_G11_10 I1_I838_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I107_XG_MP0 (VDD I1_I838_P11_10 XI1_I838_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I107_XG_MP1 (XI1_I838_I107_XG_p1 I1_I838_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I105_XG_MP2 (XI1_I838_I105_XG_p1 I1_I838_G9_8 I1_I838_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I105_XG_MP0 (VDD I1_I838_P9_8 XI1_I838_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I105_XG_MP1 (XI1_I838_I105_XG_p1 I1_I838_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I103_XG_MP2 (XI1_I838_I103_XG_p1 I1_I838_G7_6 I1_I838_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I103_XG_MP0 (VDD I1_I838_P7_6 XI1_I838_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I103_XG_MP1 (XI1_I838_I103_XG_p1 I1_I838_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I101_XG_MP2 (XI1_I838_I101_XG_p1 I1_I838_G5_4 I1_I838_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I101_XG_MP0 (VDD I1_I838_P5_4 XI1_I838_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I101_XG_MP1 (XI1_I838_I101_XG_p1 I1_I838_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I164_XG_MP2 (XI1_I792_I164_XG_p1 I1_I792_G13_6 I1_I792_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I164_XG_MP0 (VDD I1_I792_P13_6 XI1_I792_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I164_XG_MP1 (XI1_I792_I164_XG_p1 I1_I792_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I162_XG_MP2 (XI1_I792_I162_XG_p1 I1_I792_G11_4 I1_I792_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I162_XG_MP0 (VDD I1_I792_P11_4 XI1_I792_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I162_XG_MP1 (XI1_I792_I162_XG_p1 I1_I792_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I113_XG_MP2 (XI1_I792_I113_XG_p1 I1_I792_G17_16 I1_I792_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I113_XG_MP0 (VDD I1_I792_P17_16 XI1_I792_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I113_XG_MP1 (XI1_I792_I113_XG_p1 I1_I792_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I171_XG_MP2 (XI1_I792_I171_XG_p1 I1_I792_G20_13 I1_I792_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I171_XG_MP0 (VDD I1_I792_P20_13 XI1_I792_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I171_XG_MP1 (XI1_I792_I171_XG_p1 I1_I792_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I165_XG_MP2 (XI1_I792_I165_XG_p1 I1_I792_G14_7 I1_I792_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I165_XG_MP0 (VDD I1_I792_P14_7 XI1_I792_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I165_XG_MP1 (XI1_I792_I165_XG_p1 I1_I792_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I114_XG_MP2 (XI1_I792_I114_XG_p1 I1_I792_G18_17 I1_I792_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I114_XG_MP0 (VDD I1_I792_P18_17 XI1_I792_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I114_XG_MP1 (XI1_I792_I114_XG_p1 I1_I792_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I116_XG_MP2 (XI1_I792_I116_XG_p1 I1_I792_G20_19 I1_I792_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I116_XG_MP0 (VDD I1_I792_P20_19 XI1_I792_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I116_XG_MP1 (XI1_I792_I116_XG_p1 I1_I792_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I173_XG_MP2 (XI1_I746_I173_XG_p1 I1_I746_G22_15 I1_I746_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I173_XG_MP0 (VDD I1_I746_P22_15 XI1_I746_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I173_XG_MP1 (XI1_I746_I173_XG_p1 I1_I746_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I181_XG_MP2 (XI1_I746_I181_XG_p1 I1_I746_G30_23 I1_I746_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I181_XG_MP0 (VDD I1_I746_P30_23 XI1_I746_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I181_XG_MP1 (XI1_I746_I181_XG_p1 I1_I746_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I126_XG_MP2 (XI1_I746_I126_XG_p1 I1_I746_G30_29 I1_I746_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I126_XG_MP0 (VDD I1_I746_P30_29 XI1_I746_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I126_XG_MP1 (XI1_I746_I126_XG_p1 I1_I746_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I122_XG_MP2 (XI1_I1344_I122_XG_p1 I1_I1344_G26_25 I1_I1344_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I122_XG_MP0 (VDD I1_I1344_P26_25 XI1_I1344_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I122_XG_MP1 (XI1_I1344_I122_XG_p1 I1_I1344_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I124_XG_MP2 (XI1_I1344_I124_XG_p1 I1_I1344_G28_27 I1_I1344_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I124_XG_MP0 (VDD I1_I1344_P28_27 XI1_I1344_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I124_XG_MP1 (XI1_I1344_I124_XG_p1 I1_I1344_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I172_XG_MP2 (XI1_I1344_I172_XG_p1 I1_I1344_G21_14 I1_I1344_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I172_XG_MP0 (VDD I1_I1344_P21_14 XI1_I1344_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I172_XG_MP1 (XI1_I1344_I172_XG_p1 I1_I1344_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I164_XG_MP2 (XI1_I1344_I164_XG_p1 I1_I1344_G13_6 I1_I1344_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I164_XG_MP0 (VDD I1_I1344_P13_6 XI1_I1344_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I164_XG_MP1 (XI1_I1344_I164_XG_p1 I1_I1344_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I109_XG_MP2 (XI1_I1344_I109_XG_p1 I1_I1344_G13_12 I1_I1344_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I109_XG_MP0 (VDD I1_I1344_P13_12 XI1_I1344_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I109_XG_MP1 (XI1_I1344_I109_XG_p1 I1_I1344_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I166_XG_MP2 (XI1_I1298_I166_XG_p1 I1_I1298_G15_8 I1_I1298_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I166_XG_MP0 (VDD I1_I1298_P15_8 XI1_I1298_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I166_XG_MP1 (XI1_I1298_I166_XG_p1 I1_I1298_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I172_XG_MP2 (XI1_I1298_I172_XG_p1 I1_I1298_G21_14 I1_I1298_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I172_XG_MP0 (VDD I1_I1298_P21_14 XI1_I1298_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I172_XG_MP1 (XI1_I1298_I172_XG_p1 I1_I1298_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I117_XG_MP2 (XI1_I1298_I117_XG_p1 I1_I1298_G21_20 I1_I1298_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I117_XG_MP0 (VDD I1_I1298_P21_20 XI1_I1298_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I117_XG_MP1 (XI1_I1298_I117_XG_p1 I1_I1298_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I177_XG_MP2 (XI1_I1298_I177_XG_p1 I1_I1298_G26_19 I1_I1298_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I177_XG_MP0 (VDD I1_I1298_P26_19 XI1_I1298_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I177_XG_MP1 (XI1_I1298_I177_XG_p1 I1_I1298_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I173_XG_MP2 (XI1_I1298_I173_XG_p1 I1_I1298_G22_15 I1_I1298_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I173_XG_MP0 (VDD I1_I1298_P22_15 XI1_I1298_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I173_XG_MP1 (XI1_I1298_I173_XG_p1 I1_I1298_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I118_XG_MP2 (XI1_I1298_I118_XG_p1 I1_I1298_G22_21 I1_I1298_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I118_XG_MP0 (VDD I1_I1298_P22_21 XI1_I1298_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I118_XG_MP1 (XI1_I1298_I118_XG_p1 I1_I1298_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I173_XG_MP2 (XI1_I1252_I173_XG_p1 I1_I1252_G22_15 I1_I1252_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I173_XG_MP0 (VDD I1_I1252_P22_15 XI1_I1252_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I173_XG_MP1 (XI1_I1252_I173_XG_p1 I1_I1252_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I118_XG_MP2 (XI1_I1252_I118_XG_p1 I1_I1252_G22_21 I1_I1252_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I118_XG_MP0 (VDD I1_I1252_P22_21 XI1_I1252_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I118_XG_MP1 (XI1_I1252_I118_XG_p1 I1_I1252_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I166_XG_MP2 (XI1_I1252_I166_XG_p1 I1_I1252_G15_8 I1_I1252_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I166_XG_MP0 (VDD I1_I1252_P15_8 XI1_I1252_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I166_XG_MP1 (XI1_I1252_I166_XG_p1 I1_I1252_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I178_XG_MP2 (XI1_I1252_I178_XG_p1 I1_I1252_G27_20 I1_I1252_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I178_XG_MP0 (VDD I1_I1252_P27_20 XI1_I1252_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I178_XG_MP1 (XI1_I1252_I178_XG_p1 I1_I1252_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I117_XG_MP2 (XI1_I1252_I117_XG_p1 I1_I1252_G21_20 I1_I1252_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I117_XG_MP0 (VDD I1_I1252_P21_20 XI1_I1252_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I117_XG_MP1 (XI1_I1252_I117_XG_p1 I1_I1252_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I178_XG_MP2 (XI1_I1206_I178_XG_p1 I1_I1206_G27_20 I1_I1206_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I178_XG_MP0 (VDD I1_I1206_P27_20 XI1_I1206_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I178_XG_MP1 (XI1_I1206_I178_XG_p1 I1_I1206_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I180_XG_MP2 (XI1_I1206_I180_XG_p1 I1_I1206_G29_22 I1_I1206_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I180_XG_MP0 (VDD I1_I1206_P29_22 XI1_I1206_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I180_XG_MP1 (XI1_I1206_I180_XG_p1 I1_I1206_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I118_XG_MP2 (XI1_I1206_I118_XG_p1 I1_I1206_G22_21 I1_I1206_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I118_XG_MP0 (VDD I1_I1206_P22_21 XI1_I1206_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I118_XG_MP1 (XI1_I1206_I118_XG_p1 I1_I1206_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I179_XG_MP2 (XI1_I1206_I179_XG_p1 I1_I1206_G28_21 I1_I1206_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I179_XG_MP0 (VDD I1_I1206_P28_21 XI1_I1206_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I179_XG_MP1 (XI1_I1206_I179_XG_p1 I1_I1206_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I181_XG_MP2 (XI1_I838_I181_XG_p1 I1_I838_G30_23 I1_I838_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I181_XG_MP0 (VDD I1_I838_P30_23 XI1_I838_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I181_XG_MP1 (XI1_I838_I181_XG_p1 I1_I838_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I179_XG_MP2 (XI1_I838_I179_XG_p1 I1_I838_G28_21 I1_I838_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I179_XG_MP0 (VDD I1_I838_P28_21 XI1_I838_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I179_XG_MP1 (XI1_I838_I179_XG_p1 I1_I838_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I114_XG_MP2 (XI1_I838_I114_XG_p1 I1_I838_G18_17 I1_I838_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I114_XG_MP0 (VDD I1_I838_P18_17 XI1_I838_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I114_XG_MP1 (XI1_I838_I114_XG_p1 I1_I838_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I112_XG_MP2 (XI1_I838_I112_XG_p1 I1_I838_G16_15 I1_I838_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I112_XG_MP0 (VDD I1_I838_P16_15 XI1_I838_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I112_XG_MP1 (XI1_I838_I112_XG_p1 I1_I838_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I110_XG_MP2 (XI1_I838_I110_XG_p1 I1_I838_G14_13 I1_I838_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I110_XG_MP0 (VDD I1_I838_P14_13 XI1_I838_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I110_XG_MP1 (XI1_I838_I110_XG_p1 I1_I838_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I108_XG_MP2 (XI1_I838_I108_XG_p1 I1_I838_G12_11 I1_I838_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I108_XG_MP0 (VDD I1_I838_P12_11 XI1_I838_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I108_XG_MP1 (XI1_I838_I108_XG_p1 I1_I838_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I99_XG_MP2 (XI1_I838_I99_XG_p1 I1_I838_G3_2 I1_I838_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I99_XG_MP0 (VDD I1_I838_P3_2 XI1_I838_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I99_XG_MP1 (XI1_I838_I99_XG_p1 I1_I838_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I168_XG_MP2 (XI1_I792_I168_XG_p1 I1_I792_G17_10 I1_I792_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I168_XG_MP0 (VDD I1_I792_P17_10 XI1_I792_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I168_XG_MP1 (XI1_I792_I168_XG_p1 I1_I792_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I107_XG_MP2 (XI1_I792_I107_XG_p1 I1_I792_G11_10 I1_I792_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I107_XG_MP0 (VDD I1_I792_P11_10 XI1_I792_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I107_XG_MP1 (XI1_I792_I107_XG_p1 I1_I792_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I109_XG_MP2 (XI1_I792_I109_XG_p1 I1_I792_G13_12 I1_I792_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I109_XG_MP0 (VDD I1_I792_P13_12 XI1_I792_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I109_XG_MP1 (XI1_I792_I109_XG_p1 I1_I792_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I111_XG_MP2 (XI1_I792_I111_XG_p1 I1_I792_G15_14 I1_I792_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I111_XG_MP0 (VDD I1_I792_P15_14 XI1_I792_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I111_XG_MP1 (XI1_I792_I111_XG_p1 I1_I792_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I169_XG_MP2 (XI1_I792_I169_XG_p1 I1_I792_G18_11 I1_I792_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I169_XG_MP0 (VDD I1_I792_P18_11 XI1_I792_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I169_XG_MP1 (XI1_I792_I169_XG_p1 I1_I792_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I163_XG_MP2 (XI1_I792_I163_XG_p1 I1_I792_G12_5 I1_I792_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I163_XG_MP0 (VDD I1_I792_P12_5 XI1_I792_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I163_XG_MP1 (XI1_I792_I163_XG_p1 I1_I792_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I175_XG_MP2 (XI1_I792_I175_XG_p1 I1_I792_G24_17 I1_I792_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I175_XG_MP0 (VDD I1_I792_P24_17 XI1_I792_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I175_XG_MP1 (XI1_I792_I175_XG_p1 I1_I792_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I112_XG_MP2 (XI1_I792_I112_XG_p1 I1_I792_G16_15 I1_I792_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I112_XG_MP0 (VDD I1_I792_P16_15 XI1_I792_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I112_XG_MP1 (XI1_I792_I112_XG_p1 I1_I792_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I165_XG_MP2 (XI1_I746_I165_XG_p1 I1_I746_G14_7 I1_I746_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I165_XG_MP0 (VDD I1_I746_P14_7 XI1_I746_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I165_XG_MP1 (XI1_I746_I165_XG_p1 I1_I746_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I179_XG_MP2 (XI1_I746_I179_XG_p1 I1_I746_G28_21 I1_I746_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I179_XG_MP0 (VDD I1_I746_P28_21 XI1_I746_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I179_XG_MP1 (XI1_I746_I179_XG_p1 I1_I746_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I177_XG_MP2 (XI1_I746_I177_XG_p1 I1_I746_G26_19 I1_I746_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I177_XG_MP0 (VDD I1_I746_P26_19 XI1_I746_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I177_XG_MP1 (XI1_I746_I177_XG_p1 I1_I746_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I122_XG_MP2 (XI1_I746_I122_XG_p1 I1_I746_G26_25 I1_I746_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I122_XG_MP0 (VDD I1_I746_P26_25 XI1_I746_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I122_XG_MP1 (XI1_I746_I122_XG_p1 I1_I746_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I124_XG_MP2 (XI1_I746_I124_XG_p1 I1_I746_G28_27 I1_I746_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I124_XG_MP0 (VDD I1_I746_P28_27 XI1_I746_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I124_XG_MP1 (XI1_I746_I124_XG_p1 I1_I746_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I120_XG_MP2 (XI1_I1344_I120_XG_p1 I1_I1344_G24_23 I1_I1344_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I120_XG_MP0 (VDD I1_I1344_P24_23 XI1_I1344_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I120_XG_MP1 (XI1_I1344_I120_XG_p1 I1_I1344_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I118_XG_MP2 (XI1_I1344_I118_XG_p1 I1_I1344_G22_21 I1_I1344_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I118_XG_MP0 (VDD I1_I1344_P22_21 XI1_I1344_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I118_XG_MP1 (XI1_I1344_I118_XG_p1 I1_I1344_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I168_XG_MP2 (XI1_I1344_I168_XG_p1 I1_I1344_G17_10 I1_I1344_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I168_XG_MP0 (VDD I1_I1344_P17_10 XI1_I1344_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I168_XG_MP1 (XI1_I1344_I168_XG_p1 I1_I1344_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I158_XG_MP2 (XI1_I1344_I158_XG_p1 I1_I1344_G9_2 I1_I1344_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I158_XG_MP0 (VDD I1_I1344_P9_2 XI1_I1344_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I158_XG_MP1 (XI1_I1344_I158_XG_p1 I1_I1344_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I107_XG_MP2 (XI1_I1344_I107_XG_p1 I1_I1344_G11_10 I1_I1344_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I107_XG_MP0 (VDD I1_I1344_P11_10 XI1_I1344_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I107_XG_MP1 (XI1_I1344_I107_XG_p1 I1_I1344_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I170_XG_MP2 (XI1_I1298_I170_XG_p1 I1_I1298_G19_12 I1_I1298_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I170_XG_MP0 (VDD I1_I1298_P19_12 XI1_I1298_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I170_XG_MP1 (XI1_I1298_I170_XG_p1 I1_I1298_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I115_XG_MP2 (XI1_I1298_I115_XG_p1 I1_I1298_G19_18 I1_I1298_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I115_XG_MP0 (VDD I1_I1298_P19_18 XI1_I1298_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I115_XG_MP1 (XI1_I1298_I115_XG_p1 I1_I1298_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I165_XG_MP2 (XI1_I1298_I165_XG_p1 I1_I1298_G14_7 I1_I1298_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I165_XG_MP0 (VDD I1_I1298_P14_7 XI1_I1298_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I165_XG_MP1 (XI1_I1298_I165_XG_p1 I1_I1298_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I171_XG_MP2 (XI1_I1298_I171_XG_p1 I1_I1298_G20_13 I1_I1298_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I171_XG_MP0 (VDD I1_I1298_P20_13 XI1_I1298_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I171_XG_MP1 (XI1_I1298_I171_XG_p1 I1_I1298_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I116_XG_MP2 (XI1_I1298_I116_XG_p1 I1_I1298_G20_19 I1_I1298_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I116_XG_MP0 (VDD I1_I1298_P20_19 XI1_I1298_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I116_XG_MP1 (XI1_I1298_I116_XG_p1 I1_I1298_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I175_XG_MP2 (XI1_I1252_I175_XG_p1 I1_I1252_G24_17 I1_I1252_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I175_XG_MP0 (VDD I1_I1252_P24_17 XI1_I1252_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I175_XG_MP1 (XI1_I1252_I175_XG_p1 I1_I1252_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I165_XG_MP2 (XI1_I1252_I165_XG_p1 I1_I1252_G14_7 I1_I1252_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I165_XG_MP0 (VDD I1_I1252_P14_7 XI1_I1252_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I165_XG_MP1 (XI1_I1252_I165_XG_p1 I1_I1252_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I116_XG_MP2 (XI1_I1252_I116_XG_p1 I1_I1252_G20_19 I1_I1252_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I116_XG_MP0 (VDD I1_I1252_P20_19 XI1_I1252_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I116_XG_MP1 (XI1_I1252_I116_XG_p1 I1_I1252_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I164_XG_MP2 (XI1_I1252_I164_XG_p1 I1_I1252_G13_6 I1_I1252_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I164_XG_MP0 (VDD I1_I1252_P13_6 XI1_I1252_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I164_XG_MP1 (XI1_I1252_I164_XG_p1 I1_I1252_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I172_XG_MP2 (XI1_I1252_I172_XG_p1 I1_I1252_G21_14 I1_I1252_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I172_XG_MP0 (VDD I1_I1252_P21_14 XI1_I1252_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I172_XG_MP1 (XI1_I1252_I172_XG_p1 I1_I1252_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I115_XG_MP2 (XI1_I1252_I115_XG_p1 I1_I1252_G19_18 I1_I1252_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I115_XG_MP0 (VDD I1_I1252_P19_18 XI1_I1252_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I115_XG_MP1 (XI1_I1252_I115_XG_p1 I1_I1252_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I117_XG_MP2 (XI1_I1206_I117_XG_p1 I1_I1206_G21_20 I1_I1206_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I117_XG_MP0 (VDD I1_I1206_P21_20 XI1_I1206_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I117_XG_MP1 (XI1_I1206_I117_XG_p1 I1_I1206_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I182_XG_MP2 (XI1_I1206_I182_XG_p1 I1_I1206_G31_24 I1_I1206_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I182_XG_MP0 (VDD I1_I1206_P31_24 XI1_I1206_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I182_XG_MP1 (XI1_I1206_I182_XG_p1 I1_I1206_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I174_XG_MP2 (XI1_I1206_I174_XG_p1 I1_I1206_G23_16 I1_I1206_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I174_XG_MP0 (VDD I1_I1206_P23_16 XI1_I1206_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I174_XG_MP1 (XI1_I1206_I174_XG_p1 I1_I1206_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I172_XG_MP2 (XI1_I1206_I172_XG_p1 I1_I1206_G21_14 I1_I1206_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I172_XG_MP0 (VDD I1_I1206_P21_14 XI1_I1206_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I172_XG_MP1 (XI1_I1206_I172_XG_p1 I1_I1206_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I116_XG_MP2 (XI1_I1206_I116_XG_p1 I1_I1206_G20_19 I1_I1206_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I116_XG_MP0 (VDD I1_I1206_P20_19 XI1_I1206_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I116_XG_MP1 (XI1_I1206_I116_XG_p1 I1_I1206_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I173_XG_MP2 (XI1_I1206_I173_XG_p1 I1_I1206_G22_15 I1_I1206_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I173_XG_MP0 (VDD I1_I1206_P22_15 XI1_I1206_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I173_XG_MP1 (XI1_I1206_I173_XG_p1 I1_I1206_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I177_XG_MP2 (XI1_I1206_I177_XG_p1 I1_I1206_G26_19 I1_I1206_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I177_XG_MP0 (VDD I1_I1206_P26_19 XI1_I1206_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I177_XG_MP1 (XI1_I1206_I177_XG_p1 I1_I1206_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I165_XG_MP2 (XI1_I838_I165_XG_p1 I1_I838_G14_7 I1_I838_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I165_XG_MP0 (VDD I1_I838_P14_7 XI1_I838_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I165_XG_MP1 (XI1_I838_I165_XG_p1 I1_I838_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I175_XG_MP2 (XI1_I838_I175_XG_p1 I1_I838_G24_17 I1_I838_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I175_XG_MP0 (VDD I1_I838_P24_17 XI1_I838_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I175_XG_MP1 (XI1_I838_I175_XG_p1 I1_I838_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I160_XG_MP2 (XI1_I838_I160_XG_p1 I1_I838_G10_3 I1_I838_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I160_XG_MP0 (VDD I1_I838_P10_3 XI1_I838_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I160_XG_MP1 (XI1_I838_I160_XG_p1 I1_I838_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I106_XG_MP2 (XI1_I838_I106_XG_p1 I1_I838_G10_9 I1_I838_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I106_XG_MP0 (VDD I1_I838_P10_9 XI1_I838_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I106_XG_MP1 (XI1_I838_I106_XG_p1 I1_I838_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I158_XG_MP2 (XI1_I792_I158_XG_p1 I1_I792_G9_2 I1_I792_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I158_XG_MP0 (VDD I1_I792_P9_2 XI1_I792_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I158_XG_MP1 (XI1_I792_I158_XG_p1 I1_I792_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I105_XG_MP2 (XI1_I792_I105_XG_p1 I1_I792_G9_8 I1_I792_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I105_XG_MP0 (VDD I1_I792_P9_8 XI1_I792_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I105_XG_MP1 (XI1_I792_I105_XG_p1 I1_I792_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I160_XG_MP2 (XI1_I792_I160_XG_p1 I1_I792_G10_3 I1_I792_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I160_XG_MP0 (VDD I1_I792_P10_3 XI1_I792_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I160_XG_MP1 (XI1_I792_I160_XG_p1 I1_I792_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I110_XG_MP2 (XI1_I792_I110_XG_p1 I1_I792_G14_13 I1_I792_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I110_XG_MP0 (VDD I1_I792_P14_13 XI1_I792_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I110_XG_MP1 (XI1_I792_I110_XG_p1 I1_I792_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I160_XG_MP2 (XI1_I746_I160_XG_p1 I1_I746_G10_3 I1_I746_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I160_XG_MP0 (VDD I1_I746_P10_3 XI1_I746_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I160_XG_MP1 (XI1_I746_I160_XG_p1 I1_I746_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I169_XG_MP2 (XI1_I746_I169_XG_p1 I1_I746_G18_11 I1_I746_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I169_XG_MP0 (VDD I1_I746_P18_11 XI1_I746_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I169_XG_MP1 (XI1_I746_I169_XG_p1 I1_I746_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I175_XG_MP2 (XI1_I746_I175_XG_p1 I1_I746_G24_17 I1_I746_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I175_XG_MP0 (VDD I1_I746_P24_17 XI1_I746_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I175_XG_MP1 (XI1_I746_I175_XG_p1 I1_I746_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I118_XG_MP2 (XI1_I746_I118_XG_p1 I1_I746_G22_21 I1_I746_G22_19n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I118_XG_MP0 (VDD I1_I746_P22_21 XI1_I746_I118_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I118_XG_MP1 (XI1_I746_I118_XG_p1 I1_I746_G20_19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I120_XG_MP2 (XI1_I746_I120_XG_p1 I1_I746_G24_23 I1_I746_G24_21n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I120_XG_MP0 (VDD I1_I746_P24_23 XI1_I746_I120_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I120_XG_MP1 (XI1_I746_I120_XG_p1 I1_I746_G22_21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I181_XG_MP2 (XI1_I1344_I181_XG_p1 I1_I1344_G30_23 I1_I1344_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I181_XG_MP0 (VDD I1_I1344_P30_23 XI1_I1344_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I181_XG_MP1 (XI1_I1344_I181_XG_p1 I1_I1344_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I116_XG_MP2 (XI1_I1344_I116_XG_p1 I1_I1344_G20_19 I1_I1344_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I116_XG_MP0 (VDD I1_I1344_P20_19 XI1_I1344_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I116_XG_MP1 (XI1_I1344_I116_XG_p1 I1_I1344_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I114_XG_MP2 (XI1_I1344_I114_XG_p1 I1_I1344_G18_17 I1_I1344_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I114_XG_MP0 (VDD I1_I1344_P18_17 XI1_I1344_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I114_XG_MP1 (XI1_I1344_I114_XG_p1 I1_I1344_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I105_XG_MP2 (XI1_I1344_I105_XG_p1 I1_I1344_G9_8 I1_I1344_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I105_XG_MP0 (VDD I1_I1344_P9_8 XI1_I1344_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I105_XG_MP1 (XI1_I1344_I105_XG_p1 I1_I1344_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I162_XG_MP2 (XI1_I1298_I162_XG_p1 I1_I1298_G11_4 I1_I1298_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I162_XG_MP0 (VDD I1_I1298_P11_4 XI1_I1298_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I162_XG_MP1 (XI1_I1298_I162_XG_p1 I1_I1298_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I164_XG_MP2 (XI1_I1298_I164_XG_p1 I1_I1298_G13_6 I1_I1298_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I164_XG_MP0 (VDD I1_I1298_P13_6 XI1_I1298_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I164_XG_MP1 (XI1_I1298_I164_XG_p1 I1_I1298_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I113_XG_MP2 (XI1_I1298_I113_XG_p1 I1_I1298_G17_16 I1_I1298_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I113_XG_MP0 (VDD I1_I1298_P17_16 XI1_I1298_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I113_XG_MP1 (XI1_I1298_I113_XG_p1 I1_I1298_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I114_XG_MP2 (XI1_I1298_I114_XG_p1 I1_I1298_G18_17 I1_I1298_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I114_XG_MP0 (VDD I1_I1298_P18_17 XI1_I1298_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I114_XG_MP1 (XI1_I1298_I114_XG_p1 I1_I1298_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I171_XG_MP2 (XI1_I1252_I171_XG_p1 I1_I1252_G20_13 I1_I1252_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I171_XG_MP0 (VDD I1_I1252_P20_13 XI1_I1252_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I171_XG_MP1 (XI1_I1252_I171_XG_p1 I1_I1252_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I114_XG_MP2 (XI1_I1252_I114_XG_p1 I1_I1252_G18_17 I1_I1252_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I114_XG_MP0 (VDD I1_I1252_P18_17 XI1_I1252_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I114_XG_MP1 (XI1_I1252_I114_XG_p1 I1_I1252_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I176_XG_MP2 (XI1_I1252_I176_XG_p1 I1_I1252_G25_18 I1_I1252_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I176_XG_MP0 (VDD I1_I1252_P25_18 XI1_I1252_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I176_XG_MP1 (XI1_I1252_I176_XG_p1 I1_I1252_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I113_XG_MP2 (XI1_I1252_I113_XG_p1 I1_I1252_G17_16 I1_I1252_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I113_XG_MP0 (VDD I1_I1252_P17_16 XI1_I1252_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I113_XG_MP1 (XI1_I1252_I113_XG_p1 I1_I1252_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I115_XG_MP2 (XI1_I1206_I115_XG_p1 I1_I1206_G19_18 I1_I1206_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I115_XG_MP0 (VDD I1_I1206_P19_18 XI1_I1206_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I115_XG_MP1 (XI1_I1206_I115_XG_p1 I1_I1206_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I166_XG_MP2 (XI1_I1206_I166_XG_p1 I1_I1206_G15_8 I1_I1206_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I166_XG_MP0 (VDD I1_I1206_P15_8 XI1_I1206_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I166_XG_MP1 (XI1_I1206_I166_XG_p1 I1_I1206_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I176_XG_MP2 (XI1_I1206_I176_XG_p1 I1_I1206_G25_18 I1_I1206_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I176_XG_MP0 (VDD I1_I1206_P25_18 XI1_I1206_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I176_XG_MP1 (XI1_I1206_I176_XG_p1 I1_I1206_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I114_XG_MP2 (XI1_I1206_I114_XG_p1 I1_I1206_G18_17 I1_I1206_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I114_XG_MP0 (VDD I1_I1206_P18_17 XI1_I1206_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I114_XG_MP1 (XI1_I1206_I114_XG_p1 I1_I1206_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I169_XG_MP2 (XI1_I1206_I169_XG_p1 I1_I1206_G18_11 I1_I1206_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I169_XG_MP0 (VDD I1_I1206_P18_11 XI1_I1206_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I169_XG_MP1 (XI1_I1206_I169_XG_p1 I1_I1206_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I175_XG_MP2 (XI1_I1206_I175_XG_p1 I1_I1206_G24_17 I1_I1206_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I175_XG_MP0 (VDD I1_I1206_P24_17 XI1_I1206_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I175_XG_MP1 (XI1_I1206_I175_XG_p1 I1_I1206_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I171_XG_MP2 (XI1_I838_I171_XG_p1 I1_I838_G20_13 I1_I838_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I171_XG_MP0 (VDD I1_I838_P20_13 XI1_I838_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I171_XG_MP1 (XI1_I838_I171_XG_p1 I1_I838_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I163_XG_MP2 (XI1_I838_I163_XG_p1 I1_I838_G12_5 I1_I838_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I163_XG_MP0 (VDD I1_I838_P12_5 XI1_I838_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I163_XG_MP1 (XI1_I838_I163_XG_p1 I1_I838_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I169_XG_MP2 (XI1_I838_I169_XG_p1 I1_I838_G18_11 I1_I838_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I169_XG_MP0 (VDD I1_I838_P18_11 XI1_I838_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I169_XG_MP1 (XI1_I838_I169_XG_p1 I1_I838_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I167_XG_MP2 (XI1_I838_I167_XG_p1 I1_I838_G16_9 I1_I838_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I167_XG_MP0 (VDD I1_I838_P16_9 XI1_I838_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I167_XG_MP1 (XI1_I838_I167_XG_p1 I1_I838_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I157_XG_MP2 (XI1_I838_I157_XG_p1 I1_I838_G8_1 I1_I838_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I157_XG_MP0 (VDD I1_I838_P8_1 XI1_I838_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I157_XG_MP1 (XI1_I838_I157_XG_p1 I1_I838_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I104_XG_MP2 (XI1_I838_I104_XG_p1 I1_I838_G8_7 I1_I838_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I104_XG_MP0 (VDD I1_I838_P8_7 XI1_I838_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I104_XG_MP1 (XI1_I838_I104_XG_p1 I1_I838_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I102_XG_MP2 (XI1_I838_I102_XG_p1 I1_I838_G6_5 I1_I838_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I102_XG_MP0 (VDD I1_I838_P6_5 XI1_I838_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I102_XG_MP1 (XI1_I838_I102_XG_p1 I1_I838_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I103_XG_MP2 (XI1_I792_I103_XG_p1 I1_I792_G7_6 I1_I792_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I103_XG_MP0 (VDD I1_I792_P7_6 XI1_I792_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I103_XG_MP1 (XI1_I792_I103_XG_p1 I1_I792_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I157_XG_MP2 (XI1_I792_I157_XG_p1 I1_I792_G8_1 I1_I792_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I157_XG_MP0 (VDD I1_I792_P8_1 XI1_I792_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I157_XG_MP1 (XI1_I792_I157_XG_p1 I1_I792_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I167_XG_MP2 (XI1_I792_I167_XG_p1 I1_I792_G16_9 I1_I792_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I167_XG_MP0 (VDD I1_I792_P16_9 XI1_I792_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I167_XG_MP1 (XI1_I792_I167_XG_p1 I1_I792_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I106_XG_MP2 (XI1_I792_I106_XG_p1 I1_I792_G10_9 I1_I792_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I106_XG_MP0 (VDD I1_I792_P10_9 XI1_I792_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I106_XG_MP1 (XI1_I792_I106_XG_p1 I1_I792_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I108_XG_MP2 (XI1_I792_I108_XG_p1 I1_I792_G12_11 I1_I792_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I108_XG_MP0 (VDD I1_I792_P12_11 XI1_I792_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I108_XG_MP1 (XI1_I792_I108_XG_p1 I1_I792_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I167_XG_MP2 (XI1_I746_I167_XG_p1 I1_I746_G16_9 I1_I746_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I167_XG_MP0 (VDD I1_I746_P16_9 XI1_I746_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I167_XG_MP1 (XI1_I746_I167_XG_p1 I1_I746_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I163_XG_MP2 (XI1_I746_I163_XG_p1 I1_I746_G12_5 I1_I746_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I163_XG_MP0 (VDD I1_I746_P12_5 XI1_I746_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I163_XG_MP1 (XI1_I746_I163_XG_p1 I1_I746_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I171_XG_MP2 (XI1_I746_I171_XG_p1 I1_I746_G20_13 I1_I746_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I171_XG_MP0 (VDD I1_I746_P20_13 XI1_I746_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I171_XG_MP1 (XI1_I746_I171_XG_p1 I1_I746_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I114_XG_MP2 (XI1_I746_I114_XG_p1 I1_I746_G18_17 I1_I746_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I114_XG_MP0 (VDD I1_I746_P18_17 XI1_I746_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I114_XG_MP1 (XI1_I746_I114_XG_p1 I1_I746_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I116_XG_MP2 (XI1_I746_I116_XG_p1 I1_I746_G20_19 I1_I746_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I116_XG_MP0 (VDD I1_I746_P20_19 XI1_I746_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I116_XG_MP1 (XI1_I746_I116_XG_p1 I1_I746_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I125_XG_MP2 (XI1_I746_I125_XG_p1 I1_I746_G29_28 I1_I746_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I125_XG_MP0 (VDD I1_I746_P29_28 XI1_I746_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I125_XG_MP1 (XI1_I746_I125_XG_p1 I1_I746_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I177_XG_MP2 (XI1_I1344_I177_XG_p1 I1_I1344_G26_19 I1_I1344_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I177_XG_MP0 (VDD I1_I1344_P26_19 XI1_I1344_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I177_XG_MP1 (XI1_I1344_I177_XG_p1 I1_I1344_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I179_XG_MP2 (XI1_I1344_I179_XG_p1 I1_I1344_G28_21 I1_I1344_G28_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I179_XG_MP0 (VDD I1_I1344_P28_21 XI1_I1344_I179_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I179_XG_MP1 (XI1_I1344_I179_XG_p1 I1_I1344_G20_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I112_XG_MP2 (XI1_I1344_I112_XG_p1 I1_I1344_G16_15 I1_I1344_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I112_XG_MP0 (VDD I1_I1344_P16_15 XI1_I1344_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I112_XG_MP1 (XI1_I1344_I112_XG_p1 I1_I1344_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I110_XG_MP2 (XI1_I1344_I110_XG_p1 I1_I1344_G14_13 I1_I1344_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I110_XG_MP0 (VDD I1_I1344_P14_13 XI1_I1344_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I110_XG_MP1 (XI1_I1344_I110_XG_p1 I1_I1344_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I103_XG_MP2 (XI1_I1344_I103_XG_p1 I1_I1344_G7_6 I1_I1344_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I103_XG_MP0 (VDD I1_I1344_P7_6 XI1_I1344_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I103_XG_MP1 (XI1_I1344_I103_XG_p1 I1_I1344_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I109_XG_MP2 (XI1_I1298_I109_XG_p1 I1_I1298_G13_12 I1_I1298_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I109_XG_MP0 (VDD I1_I1298_P13_12 XI1_I1298_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I109_XG_MP1 (XI1_I1298_I109_XG_p1 I1_I1298_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I111_XG_MP2 (XI1_I1298_I111_XG_p1 I1_I1298_G15_14 I1_I1298_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I111_XG_MP0 (VDD I1_I1298_P15_14 XI1_I1298_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I111_XG_MP1 (XI1_I1298_I111_XG_p1 I1_I1298_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I163_XG_MP2 (XI1_I1298_I163_XG_p1 I1_I1298_G12_5 I1_I1298_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I163_XG_MP0 (VDD I1_I1298_P12_5 XI1_I1298_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I163_XG_MP1 (XI1_I1298_I163_XG_p1 I1_I1298_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I112_XG_MP2 (XI1_I1298_I112_XG_p1 I1_I1298_G16_15 I1_I1298_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I112_XG_MP0 (VDD I1_I1298_P16_15 XI1_I1298_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I112_XG_MP1 (XI1_I1298_I112_XG_p1 I1_I1298_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I110_XG_MP2 (XI1_I1298_I110_XG_p1 I1_I1298_G14_13 I1_I1298_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I110_XG_MP0 (VDD I1_I1298_P14_13 XI1_I1298_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I110_XG_MP1 (XI1_I1298_I110_XG_p1 I1_I1298_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I163_XG_MP2 (XI1_I1252_I163_XG_p1 I1_I1252_G12_5 I1_I1252_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I163_XG_MP0 (VDD I1_I1252_P12_5 XI1_I1252_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I163_XG_MP1 (XI1_I1252_I163_XG_p1 I1_I1252_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I169_XG_MP2 (XI1_I1252_I169_XG_p1 I1_I1252_G18_11 I1_I1252_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I169_XG_MP0 (VDD I1_I1252_P18_11 XI1_I1252_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I169_XG_MP1 (XI1_I1252_I169_XG_p1 I1_I1252_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I110_XG_MP2 (XI1_I1252_I110_XG_p1 I1_I1252_G14_13 I1_I1252_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I110_XG_MP0 (VDD I1_I1252_P14_13 XI1_I1252_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I110_XG_MP1 (XI1_I1252_I110_XG_p1 I1_I1252_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I112_XG_MP2 (XI1_I1252_I112_XG_p1 I1_I1252_G16_15 I1_I1252_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I112_XG_MP0 (VDD I1_I1252_P16_15 XI1_I1252_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I112_XG_MP1 (XI1_I1252_I112_XG_p1 I1_I1252_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I170_XG_MP2 (XI1_I1252_I170_XG_p1 I1_I1252_G19_12 I1_I1252_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I170_XG_MP0 (VDD I1_I1252_P19_12 XI1_I1252_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I170_XG_MP1 (XI1_I1252_I170_XG_p1 I1_I1252_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I111_XG_MP2 (XI1_I1252_I111_XG_p1 I1_I1252_G15_14 I1_I1252_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I111_XG_MP0 (VDD I1_I1252_P15_14 XI1_I1252_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I111_XG_MP1 (XI1_I1252_I111_XG_p1 I1_I1252_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I113_XG_MP2 (XI1_I1206_I113_XG_p1 I1_I1206_G17_16 I1_I1206_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I113_XG_MP0 (VDD I1_I1206_P17_16 XI1_I1206_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I113_XG_MP1 (XI1_I1206_I113_XG_p1 I1_I1206_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I170_XG_MP2 (XI1_I1206_I170_XG_p1 I1_I1206_G19_12 I1_I1206_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I170_XG_MP0 (VDD I1_I1206_P19_12 XI1_I1206_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I170_XG_MP1 (XI1_I1206_I170_XG_p1 I1_I1206_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I168_XG_MP2 (XI1_I1206_I168_XG_p1 I1_I1206_G17_10 I1_I1206_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I168_XG_MP0 (VDD I1_I1206_P17_10 XI1_I1206_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I168_XG_MP1 (XI1_I1206_I168_XG_p1 I1_I1206_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I164_XG_MP2 (XI1_I1206_I164_XG_p1 I1_I1206_G13_6 I1_I1206_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I164_XG_MP0 (VDD I1_I1206_P13_6 XI1_I1206_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I164_XG_MP1 (XI1_I1206_I164_XG_p1 I1_I1206_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I165_XG_MP2 (XI1_I1206_I165_XG_p1 I1_I1206_G14_7 I1_I1206_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I165_XG_MP0 (VDD I1_I1206_P14_7 XI1_I1206_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I165_XG_MP1 (XI1_I1206_I165_XG_p1 I1_I1206_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I171_XG_MP2 (XI1_I1206_I171_XG_p1 I1_I1206_G20_13 I1_I1206_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I171_XG_MP0 (VDD I1_I1206_P20_13 XI1_I1206_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I171_XG_MP1 (XI1_I1206_I171_XG_p1 I1_I1206_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I101_XG_MP2 (XI1_I792_I101_XG_p1 I1_I792_G5_4 I1_I792_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I101_XG_MP0 (VDD I1_I792_P5_4 XI1_I792_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I101_XG_MP1 (XI1_I792_I101_XG_p1 I1_I792_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I102_XG_MP2 (XI1_I792_I102_XG_p1 I1_I792_G6_5 I1_I792_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I102_XG_MP0 (VDD I1_I792_P6_5 XI1_I792_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I102_XG_MP1 (XI1_I792_I102_XG_p1 I1_I792_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I104_XG_MP2 (XI1_I792_I104_XG_p1 I1_I792_G8_7 I1_I792_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I104_XG_MP0 (VDD I1_I792_P8_7 XI1_I792_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I104_XG_MP1 (XI1_I792_I104_XG_p1 I1_I792_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I157_XG_MP2 (XI1_I746_I157_XG_p1 I1_I746_G8_1 I1_I746_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I157_XG_MP0 (VDD I1_I746_P8_1 XI1_I746_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I157_XG_MP1 (XI1_I746_I157_XG_p1 I1_I746_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I106_XG_MP2 (XI1_I746_I106_XG_p1 I1_I746_G10_9 I1_I746_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I106_XG_MP0 (VDD I1_I746_P10_9 XI1_I746_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I106_XG_MP1 (XI1_I746_I106_XG_p1 I1_I746_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I108_XG_MP2 (XI1_I746_I108_XG_p1 I1_I746_G12_11 I1_I746_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I108_XG_MP0 (VDD I1_I746_P12_11 XI1_I746_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I108_XG_MP1 (XI1_I746_I108_XG_p1 I1_I746_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I110_XG_MP2 (XI1_I746_I110_XG_p1 I1_I746_G14_13 I1_I746_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I110_XG_MP0 (VDD I1_I746_P14_13 XI1_I746_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I110_XG_MP1 (XI1_I746_I110_XG_p1 I1_I746_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I112_XG_MP2 (XI1_I746_I112_XG_p1 I1_I746_G16_15 I1_I746_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I112_XG_MP0 (VDD I1_I746_P16_15 XI1_I746_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I112_XG_MP1 (XI1_I746_I112_XG_p1 I1_I746_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I164_XG_MP2 (XI1_I746_I164_XG_p1 I1_I746_G13_6 I1_I746_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I164_XG_MP0 (VDD I1_I746_P13_6 XI1_I746_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I164_XG_MP1 (XI1_I746_I164_XG_p1 I1_I746_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I176_XG_MP2 (XI1_I746_I176_XG_p1 I1_I746_G25_18 I1_I746_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I176_XG_MP0 (VDD I1_I746_P25_18 XI1_I746_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I176_XG_MP1 (XI1_I746_I176_XG_p1 I1_I746_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I172_XG_MP2 (XI1_I746_I172_XG_p1 I1_I746_G21_14 I1_I746_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I172_XG_MP0 (VDD I1_I746_P21_14 XI1_I746_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I172_XG_MP1 (XI1_I746_I172_XG_p1 I1_I746_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I180_XG_MP2 (XI1_I746_I180_XG_p1 I1_I746_G29_22 I1_I746_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I180_XG_MP0 (VDD I1_I746_P29_22 XI1_I746_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I180_XG_MP1 (XI1_I746_I180_XG_p1 I1_I746_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I121_XG_MP2 (XI1_I746_I121_XG_p1 I1_I746_G25_24 I1_I746_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I121_XG_MP0 (VDD I1_I746_P25_24 XI1_I746_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I121_XG_MP1 (XI1_I746_I121_XG_p1 I1_I746_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I123_XG_MP2 (XI1_I746_I123_XG_p1 I1_I746_G27_26 I1_I746_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I123_XG_MP0 (VDD I1_I746_P27_26 XI1_I746_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I123_XG_MP1 (XI1_I746_I123_XG_p1 I1_I746_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I127_XG_MP2 (XI1_I746_I127_XG_p1 I1_I746_G31_30 I1_I746_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I127_XG_MP0 (VDD I1_I746_P31_30 XI1_I746_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I127_XG_MP1 (XI1_I746_I127_XG_p1 I1_I746_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I173_XG_MP2 (XI1_I1344_I173_XG_p1 I1_I1344_G22_15 I1_I1344_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I173_XG_MP0 (VDD I1_I1344_P22_15 XI1_I1344_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I173_XG_MP1 (XI1_I1344_I173_XG_p1 I1_I1344_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I165_XG_MP2 (XI1_I1344_I165_XG_p1 I1_I1344_G14_7 I1_I1344_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I165_XG_MP0 (VDD I1_I1344_P14_7 XI1_I1344_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I165_XG_MP1 (XI1_I1344_I165_XG_p1 I1_I1344_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I175_XG_MP2 (XI1_I1344_I175_XG_p1 I1_I1344_G24_17 I1_I1344_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I175_XG_MP0 (VDD I1_I1344_P24_17 XI1_I1344_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I175_XG_MP1 (XI1_I1344_I175_XG_p1 I1_I1344_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I171_XG_MP2 (XI1_I1344_I171_XG_p1 I1_I1344_G20_13 I1_I1344_G20_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I171_XG_MP0 (VDD I1_I1344_P20_13 XI1_I1344_I171_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I171_XG_MP1 (XI1_I1344_I171_XG_p1 I1_I1344_G12_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I108_XG_MP2 (XI1_I1344_I108_XG_p1 I1_I1344_G12_11 I1_I1344_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I108_XG_MP0 (VDD I1_I1344_P12_11 XI1_I1344_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I108_XG_MP1 (XI1_I1344_I108_XG_p1 I1_I1344_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I168_XG_MP2 (XI1_I1298_I168_XG_p1 I1_I1298_G17_10 I1_I1298_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I168_XG_MP0 (VDD I1_I1298_P17_10 XI1_I1298_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I168_XG_MP1 (XI1_I1298_I168_XG_p1 I1_I1298_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I107_XG_MP2 (XI1_I1298_I107_XG_p1 I1_I1298_G11_10 I1_I1298_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I107_XG_MP0 (VDD I1_I1298_P11_10 XI1_I1298_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I107_XG_MP1 (XI1_I1298_I107_XG_p1 I1_I1298_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I169_XG_MP2 (XI1_I1298_I169_XG_p1 I1_I1298_G18_11 I1_I1298_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I169_XG_MP0 (VDD I1_I1298_P18_11 XI1_I1298_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I169_XG_MP1 (XI1_I1298_I169_XG_p1 I1_I1298_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I175_XG_MP2 (XI1_I1298_I175_XG_p1 I1_I1298_G24_17 I1_I1298_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I175_XG_MP0 (VDD I1_I1298_P24_17 XI1_I1298_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I175_XG_MP1 (XI1_I1298_I175_XG_p1 I1_I1298_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I108_XG_MP2 (XI1_I1298_I108_XG_p1 I1_I1298_G12_11 I1_I1298_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I108_XG_MP0 (VDD I1_I1298_P12_11 XI1_I1298_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I108_XG_MP1 (XI1_I1298_I108_XG_p1 I1_I1298_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I160_XG_MP2 (XI1_I1252_I160_XG_p1 I1_I1252_G10_3 I1_I1252_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I160_XG_MP0 (VDD I1_I1252_P10_3 XI1_I1252_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I160_XG_MP1 (XI1_I1252_I160_XG_p1 I1_I1252_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I168_XG_MP2 (XI1_I1252_I168_XG_p1 I1_I1252_G17_10 I1_I1252_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I168_XG_MP0 (VDD I1_I1252_P17_10 XI1_I1252_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I168_XG_MP1 (XI1_I1252_I168_XG_p1 I1_I1252_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I162_XG_MP2 (XI1_I1252_I162_XG_p1 I1_I1252_G11_4 I1_I1252_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I162_XG_MP0 (VDD I1_I1252_P11_4 XI1_I1252_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I162_XG_MP1 (XI1_I1252_I162_XG_p1 I1_I1252_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I111_XG_MP2 (XI1_I1206_I111_XG_p1 I1_I1206_G15_14 I1_I1206_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I111_XG_MP0 (VDD I1_I1206_P15_14 XI1_I1206_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I111_XG_MP1 (XI1_I1206_I111_XG_p1 I1_I1206_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I162_XG_MP2 (XI1_I1206_I162_XG_p1 I1_I1206_G11_4 I1_I1206_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I162_XG_MP0 (VDD I1_I1206_P11_4 XI1_I1206_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I162_XG_MP1 (XI1_I1206_I162_XG_p1 I1_I1206_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I110_XG_MP2 (XI1_I1206_I110_XG_p1 I1_I1206_G14_13 I1_I1206_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I110_XG_MP0 (VDD I1_I1206_P14_13 XI1_I1206_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I110_XG_MP1 (XI1_I1206_I110_XG_p1 I1_I1206_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I112_XG_MP2 (XI1_I1206_I112_XG_p1 I1_I1206_G16_15 I1_I1206_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I112_XG_MP0 (VDD I1_I1206_P16_15 XI1_I1206_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I112_XG_MP1 (XI1_I1206_I112_XG_p1 I1_I1206_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I160_XG_MP2 (XI1_I1206_I160_XG_p1 I1_I1206_G10_3 I1_I1206_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I160_XG_MP0 (VDD I1_I1206_P10_3 XI1_I1206_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I160_XG_MP1 (XI1_I1206_I160_XG_p1 I1_I1206_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I163_XG_MP2 (XI1_I1206_I163_XG_p1 I1_I1206_G12_5 I1_I1206_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I163_XG_MP0 (VDD I1_I1206_P12_5 XI1_I1206_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I163_XG_MP1 (XI1_I1206_I163_XG_p1 I1_I1206_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I123_XG_MP2 (XI1_I884_I123_XG_p1 I1_I884_G27_26 I1_I884_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I123_XG_MP0 (VDD I1_I884_P27_26 XI1_I884_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I123_XG_MP1 (XI1_I884_I123_XG_p1 I1_I884_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I121_XG_MP2 (XI1_I884_I121_XG_p1 I1_I884_G25_24 I1_I884_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I121_XG_MP0 (VDD I1_I884_P25_24 XI1_I884_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I121_XG_MP1 (XI1_I884_I121_XG_p1 I1_I884_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I119_XG_MP2 (XI1_I884_I119_XG_p1 I1_I884_G23_22 I1_I884_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I119_XG_MP0 (VDD I1_I884_P23_22 XI1_I884_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I119_XG_MP1 (XI1_I884_I119_XG_p1 I1_I884_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I117_XG_MP2 (XI1_I884_I117_XG_p1 I1_I884_G21_20 I1_I884_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I117_XG_MP0 (VDD I1_I884_P21_20 XI1_I884_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I117_XG_MP1 (XI1_I884_I117_XG_p1 I1_I884_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I100_XG_MP2 (XI1_I838_I100_XG_p1 I1_I838_G4_3 I1_I838_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I100_XG_MP0 (VDD I1_I838_P4_3 XI1_I838_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I100_XG_MP1 (XI1_I838_I100_XG_p1 I1_I838_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I98_XG_MP2 (XI1_I838_I98_XG_p1 I1_I838_G2_1 I1_I838_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I98_XG_MP0 (VDD I1_I838_P2_1 XI1_I838_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I98_XG_MP1 (XI1_I838_I98_XG_p1 I1_I838_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I99_XG_MP2 (XI1_I792_I99_XG_p1 I1_I792_G3_2 I1_I792_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I99_XG_MP0 (VDD I1_I792_P3_2 XI1_I792_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I99_XG_MP1 (XI1_I792_I99_XG_p1 I1_I792_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I98_XG_MP2 (XI1_I792_I98_XG_p1 I1_I792_G2_1 I1_I792_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I98_XG_MP0 (VDD I1_I792_P2_1 XI1_I792_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I98_XG_MP1 (XI1_I792_I98_XG_p1 I1_I792_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I100_XG_MP2 (XI1_I792_I100_XG_p1 I1_I792_G4_3 I1_I792_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I100_XG_MP0 (VDD I1_I792_P4_3 XI1_I792_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I100_XG_MP1 (XI1_I792_I100_XG_p1 I1_I792_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I102_XG_MP2 (XI1_I746_I102_XG_p1 I1_I746_G6_5 I1_I746_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I102_XG_MP0 (VDD I1_I746_P6_5 XI1_I746_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I102_XG_MP1 (XI1_I746_I102_XG_p1 I1_I746_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I104_XG_MP2 (XI1_I746_I104_XG_p1 I1_I746_G8_7 I1_I746_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I104_XG_MP0 (VDD I1_I746_P8_7 XI1_I746_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I104_XG_MP1 (XI1_I746_I104_XG_p1 I1_I746_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I158_XG_MP2 (XI1_I746_I158_XG_p1 I1_I746_G9_2 I1_I746_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I158_XG_MP0 (VDD I1_I746_P9_2 XI1_I746_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I158_XG_MP1 (XI1_I746_I158_XG_p1 I1_I746_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I168_XG_MP2 (XI1_I746_I168_XG_p1 I1_I746_G17_10 I1_I746_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I168_XG_MP0 (VDD I1_I746_P17_10 XI1_I746_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I168_XG_MP1 (XI1_I746_I168_XG_p1 I1_I746_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I162_XG_MP2 (XI1_I746_I162_XG_p1 I1_I746_G11_4 I1_I746_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I162_XG_MP0 (VDD I1_I746_P11_4 XI1_I746_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I162_XG_MP1 (XI1_I746_I162_XG_p1 I1_I746_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I170_XG_MP2 (XI1_I746_I170_XG_p1 I1_I746_G19_12 I1_I746_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I170_XG_MP0 (VDD I1_I746_P19_12 XI1_I746_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I170_XG_MP1 (XI1_I746_I170_XG_p1 I1_I746_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I115_XG_MP2 (XI1_I746_I115_XG_p1 I1_I746_G19_18 I1_I746_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I115_XG_MP0 (VDD I1_I746_P19_18 XI1_I746_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I115_XG_MP1 (XI1_I746_I115_XG_p1 I1_I746_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I117_XG_MP2 (XI1_I746_I117_XG_p1 I1_I746_G21_20 I1_I746_G21_18n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I117_XG_MP0 (VDD I1_I746_P21_20 XI1_I746_I117_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I117_XG_MP1 (XI1_I746_I117_XG_p1 I1_I746_G19_18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I178_XG_MP2 (XI1_I746_I178_XG_p1 I1_I746_G27_20 I1_I746_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I178_XG_MP0 (VDD I1_I746_P27_20 XI1_I746_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I178_XG_MP1 (XI1_I746_I178_XG_p1 I1_I746_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I119_XG_MP2 (XI1_I746_I119_XG_p1 I1_I746_G23_22 I1_I746_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I119_XG_MP0 (VDD I1_I746_P23_22 XI1_I746_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I119_XG_MP1 (XI1_I746_I119_XG_p1 I1_I746_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I182_XG_MP2 (XI1_I746_I182_XG_p1 I1_I746_G31_24 I1_I746_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I182_XG_MP0 (VDD I1_I746_P31_24 XI1_I746_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I182_XG_MP1 (XI1_I746_I182_XG_p1 I1_I746_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I169_XG_MP2 (XI1_I1344_I169_XG_p1 I1_I1344_G18_11 I1_I1344_G18_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I169_XG_MP0 (VDD I1_I1344_P18_11 XI1_I1344_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I169_XG_MP1 (XI1_I1344_I169_XG_p1 I1_I1344_G10_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I163_XG_MP2 (XI1_I1344_I163_XG_p1 I1_I1344_G12_5 I1_I1344_G12_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I163_XG_MP0 (VDD I1_I1344_P12_5 XI1_I1344_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I163_XG_MP1 (XI1_I1344_I163_XG_p1 I1_I1344_G4_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I160_XG_MP2 (XI1_I1344_I160_XG_p1 I1_I1344_G10_3 I1_I1344_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I160_XG_MP0 (VDD I1_I1344_P10_3 XI1_I1344_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I160_XG_MP1 (XI1_I1344_I160_XG_p1 I1_I1344_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I106_XG_MP2 (XI1_I1344_I106_XG_p1 I1_I1344_G10_9 I1_I1344_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I106_XG_MP0 (VDD I1_I1344_P10_9 XI1_I1344_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I106_XG_MP1 (XI1_I1344_I106_XG_p1 I1_I1344_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I158_XG_MP2 (XI1_I1298_I158_XG_p1 I1_I1298_G9_2 I1_I1298_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I158_XG_MP0 (VDD I1_I1298_P9_2 XI1_I1298_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I158_XG_MP1 (XI1_I1298_I158_XG_p1 I1_I1298_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I105_XG_MP2 (XI1_I1298_I105_XG_p1 I1_I1298_G9_8 I1_I1298_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I105_XG_MP0 (VDD I1_I1298_P9_8 XI1_I1298_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I105_XG_MP1 (XI1_I1298_I105_XG_p1 I1_I1298_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I160_XG_MP2 (XI1_I1298_I160_XG_p1 I1_I1298_G10_3 I1_I1298_G10_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I160_XG_MP0 (VDD I1_I1298_P10_3 XI1_I1298_I160_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I160_XG_MP1 (XI1_I1298_I160_XG_p1 I1_I1298_G2_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I167_XG_MP2 (XI1_I1298_I167_XG_p1 I1_I1298_G16_9 I1_I1298_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I167_XG_MP0 (VDD I1_I1298_P16_9 XI1_I1298_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I167_XG_MP1 (XI1_I1298_I167_XG_p1 I1_I1298_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I106_XG_MP2 (XI1_I1298_I106_XG_p1 I1_I1298_G10_9 I1_I1298_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I106_XG_MP0 (VDD I1_I1298_P10_9 XI1_I1298_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I106_XG_MP1 (XI1_I1298_I106_XG_p1 I1_I1298_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I167_XG_MP2 (XI1_I1252_I167_XG_p1 I1_I1252_G16_9 I1_I1252_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I167_XG_MP0 (VDD I1_I1252_P16_9 XI1_I1252_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I167_XG_MP1 (XI1_I1252_I167_XG_p1 I1_I1252_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I108_XG_MP2 (XI1_I1252_I108_XG_p1 I1_I1252_G12_11 I1_I1252_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I108_XG_MP0 (VDD I1_I1252_P12_11 XI1_I1252_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I108_XG_MP1 (XI1_I1252_I108_XG_p1 I1_I1252_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I158_XG_MP2 (XI1_I1252_I158_XG_p1 I1_I1252_G9_2 I1_I1252_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I158_XG_MP0 (VDD I1_I1252_P9_2 XI1_I1252_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I158_XG_MP1 (XI1_I1252_I158_XG_p1 I1_I1252_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I107_XG_MP2 (XI1_I1252_I107_XG_p1 I1_I1252_G11_10 I1_I1252_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I107_XG_MP0 (VDD I1_I1252_P11_10 XI1_I1252_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I107_XG_MP1 (XI1_I1252_I107_XG_p1 I1_I1252_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I109_XG_MP2 (XI1_I1252_I109_XG_p1 I1_I1252_G13_12 I1_I1252_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I109_XG_MP0 (VDD I1_I1252_P13_12 XI1_I1252_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I109_XG_MP1 (XI1_I1252_I109_XG_p1 I1_I1252_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I109_XG_MP2 (XI1_I1206_I109_XG_p1 I1_I1206_G13_12 I1_I1206_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I109_XG_MP0 (VDD I1_I1206_P13_12 XI1_I1206_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I109_XG_MP1 (XI1_I1206_I109_XG_p1 I1_I1206_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I107_XG_MP2 (XI1_I1206_I107_XG_p1 I1_I1206_G11_10 I1_I1206_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I107_XG_MP0 (VDD I1_I1206_P11_10 XI1_I1206_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I107_XG_MP1 (XI1_I1206_I107_XG_p1 I1_I1206_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I158_XG_MP2 (XI1_I1206_I158_XG_p1 I1_I1206_G9_2 I1_I1206_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I158_XG_MP0 (VDD I1_I1206_P9_2 XI1_I1206_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I158_XG_MP1 (XI1_I1206_I158_XG_p1 I1_I1206_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I108_XG_MP2 (XI1_I1206_I108_XG_p1 I1_I1206_G12_11 I1_I1206_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I108_XG_MP0 (VDD I1_I1206_P12_11 XI1_I1206_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I108_XG_MP1 (XI1_I1206_I108_XG_p1 I1_I1206_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I167_XG_MP2 (XI1_I1206_I167_XG_p1 I1_I1206_G16_9 I1_I1206_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I167_XG_MP0 (VDD I1_I1206_P16_9 XI1_I1206_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I167_XG_MP1 (XI1_I1206_I167_XG_p1 I1_I1206_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I127_XG_MP2 (XI1_I884_I127_XG_p1 I1_I884_G31_30 I1_I884_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I127_XG_MP0 (VDD I1_I884_P31_30 XI1_I884_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I127_XG_MP1 (XI1_I884_I127_XG_p1 I1_I884_G29_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I125_XG_MP2 (XI1_I884_I125_XG_p1 I1_I884_G29_28 I1_I884_G29_26n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I125_XG_MP0 (VDD I1_I884_P29_28 XI1_I884_I125_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I125_XG_MP1 (XI1_I884_I125_XG_p1 I1_I884_G27_26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I178_XG_MP2 (XI1_I884_I178_XG_p1 I1_I884_G27_20 I1_I884_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I178_XG_MP0 (VDD I1_I884_P27_20 XI1_I884_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I178_XG_MP1 (XI1_I884_I178_XG_p1 I1_I884_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I115_XG_MP2 (XI1_I884_I115_XG_p1 I1_I884_G19_18 I1_I884_G19_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I115_XG_MP0 (VDD I1_I884_P19_18 XI1_I884_I115_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I115_XG_MP1 (XI1_I884_I115_XG_p1 I1_I884_G17_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I113_XG_MP2 (XI1_I884_I113_XG_p1 I1_I884_G17_16 I1_I884_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I113_XG_MP0 (VDD I1_I884_P17_16 XI1_I884_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I113_XG_MP1 (XI1_I884_I113_XG_p1 I1_I884_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I111_XG_MP2 (XI1_I884_I111_XG_p1 I1_I884_G15_14 I1_I884_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I111_XG_MP0 (VDD I1_I884_P15_14 XI1_I884_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I111_XG_MP1 (XI1_I884_I111_XG_p1 I1_I884_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I109_XG_MP2 (XI1_I884_I109_XG_p1 I1_I884_G13_12 I1_I884_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I109_XG_MP0 (VDD I1_I884_P13_12 XI1_I884_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I109_XG_MP1 (XI1_I884_I109_XG_p1 I1_I884_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I98_XG_MP2 (XI1_I746_I98_XG_p1 I1_I746_G2_1 I1_I746_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I98_XG_MP0 (VDD I1_I746_P2_1 XI1_I746_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I98_XG_MP1 (XI1_I746_I98_XG_p1 I1_I746_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I100_XG_MP2 (XI1_I746_I100_XG_p1 I1_I746_G4_3 I1_I746_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I100_XG_MP0 (VDD I1_I746_P4_3 XI1_I746_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I100_XG_MP1 (XI1_I746_I100_XG_p1 I1_I746_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I101_XG_MP2 (XI1_I746_I101_XG_p1 I1_I746_G5_4 I1_I746_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I101_XG_MP0 (VDD I1_I746_P5_4 XI1_I746_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I101_XG_MP1 (XI1_I746_I101_XG_p1 I1_I746_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I103_XG_MP2 (XI1_I746_I103_XG_p1 I1_I746_G7_6 I1_I746_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I103_XG_MP0 (VDD I1_I746_P7_6 XI1_I746_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I103_XG_MP1 (XI1_I746_I103_XG_p1 I1_I746_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I105_XG_MP2 (XI1_I746_I105_XG_p1 I1_I746_G9_8 I1_I746_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I105_XG_MP0 (VDD I1_I746_P9_8 XI1_I746_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I105_XG_MP1 (XI1_I746_I105_XG_p1 I1_I746_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I107_XG_MP2 (XI1_I746_I107_XG_p1 I1_I746_G11_10 I1_I746_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I107_XG_MP0 (VDD I1_I746_P11_10 XI1_I746_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I107_XG_MP1 (XI1_I746_I107_XG_p1 I1_I746_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I109_XG_MP2 (XI1_I746_I109_XG_p1 I1_I746_G13_12 I1_I746_G13_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I109_XG_MP0 (VDD I1_I746_P13_12 XI1_I746_I109_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I109_XG_MP1 (XI1_I746_I109_XG_p1 I1_I746_G11_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I111_XG_MP2 (XI1_I746_I111_XG_p1 I1_I746_G15_14 I1_I746_G15_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I111_XG_MP0 (VDD I1_I746_P15_14 XI1_I746_I111_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I111_XG_MP1 (XI1_I746_I111_XG_p1 I1_I746_G13_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I113_XG_MP2 (XI1_I746_I113_XG_p1 I1_I746_G17_16 I1_I746_G17_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I113_XG_MP0 (VDD I1_I746_P17_16 XI1_I746_I113_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I113_XG_MP1 (XI1_I746_I113_XG_p1 I1_I746_G15_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I166_XG_MP2 (XI1_I746_I166_XG_p1 I1_I746_G15_8 I1_I746_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I166_XG_MP0 (VDD I1_I746_P15_8 XI1_I746_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I166_XG_MP1 (XI1_I746_I166_XG_p1 I1_I746_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I174_XG_MP2 (XI1_I746_I174_XG_p1 I1_I746_G23_16 I1_I746_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I174_XG_MP0 (VDD I1_I746_P23_16 XI1_I746_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I174_XG_MP1 (XI1_I746_I174_XG_p1 I1_I746_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I167_XG_MP2 (XI1_I1344_I167_XG_p1 I1_I1344_G16_9 I1_I1344_G16_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I167_XG_MP0 (VDD I1_I1344_P16_9 XI1_I1344_I167_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I167_XG_MP1 (XI1_I1344_I167_XG_p1 I1_I1344_G8_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I157_XG_MP2 (XI1_I1344_I157_XG_p1 I1_I1344_G8_1 I1_I1344_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I157_XG_MP0 (VDD I1_I1344_P8_1 XI1_I1344_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I157_XG_MP1 (XI1_I1344_I157_XG_p1 I1_I1344_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I104_XG_MP2 (XI1_I1344_I104_XG_p1 I1_I1344_G8_7 I1_I1344_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I104_XG_MP0 (VDD I1_I1344_P8_7 XI1_I1344_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I104_XG_MP1 (XI1_I1344_I104_XG_p1 I1_I1344_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I101_XG_MP2 (XI1_I1344_I101_XG_p1 I1_I1344_G5_4 I1_I1344_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I101_XG_MP0 (VDD I1_I1344_P5_4 XI1_I1344_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I101_XG_MP1 (XI1_I1344_I101_XG_p1 I1_I1344_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I103_XG_MP2 (XI1_I1298_I103_XG_p1 I1_I1298_G7_6 I1_I1298_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I103_XG_MP0 (VDD I1_I1298_P7_6 XI1_I1298_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I103_XG_MP1 (XI1_I1298_I103_XG_p1 I1_I1298_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I157_XG_MP2 (XI1_I1252_I157_XG_p1 I1_I1252_G8_1 I1_I1252_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I157_XG_MP0 (VDD I1_I1252_P8_1 XI1_I1252_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I157_XG_MP1 (XI1_I1252_I157_XG_p1 I1_I1252_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I106_XG_MP2 (XI1_I1252_I106_XG_p1 I1_I1252_G10_9 I1_I1252_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I106_XG_MP0 (VDD I1_I1252_P10_9 XI1_I1252_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I106_XG_MP1 (XI1_I1252_I106_XG_p1 I1_I1252_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I105_XG_MP2 (XI1_I1252_I105_XG_p1 I1_I1252_G9_8 I1_I1252_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I105_XG_MP0 (VDD I1_I1252_P9_8 XI1_I1252_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I105_XG_MP1 (XI1_I1252_I105_XG_p1 I1_I1252_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I105_XG_MP2 (XI1_I1206_I105_XG_p1 I1_I1206_G9_8 I1_I1206_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I105_XG_MP0 (VDD I1_I1206_P9_8 XI1_I1206_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I105_XG_MP1 (XI1_I1206_I105_XG_p1 I1_I1206_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I103_XG_MP2 (XI1_I1206_I103_XG_p1 I1_I1206_G7_6 I1_I1206_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I103_XG_MP0 (VDD I1_I1206_P7_6 XI1_I1206_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I103_XG_MP1 (XI1_I1206_I103_XG_p1 I1_I1206_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I106_XG_MP2 (XI1_I1206_I106_XG_p1 I1_I1206_G10_9 I1_I1206_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I106_XG_MP0 (VDD I1_I1206_P10_9 XI1_I1206_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I106_XG_MP1 (XI1_I1206_I106_XG_p1 I1_I1206_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I104_XG_MP2 (XI1_I1206_I104_XG_p1 I1_I1206_G8_7 I1_I1206_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I104_XG_MP0 (VDD I1_I1206_P8_7 XI1_I1206_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I104_XG_MP1 (XI1_I1206_I104_XG_p1 I1_I1206_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I182_XG_MP2 (XI1_I884_I182_XG_p1 I1_I884_G31_24 I1_I884_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I182_XG_MP0 (VDD I1_I884_P31_24 XI1_I884_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I182_XG_MP1 (XI1_I884_I182_XG_p1 I1_I884_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I180_XG_MP2 (XI1_I884_I180_XG_p1 I1_I884_G29_22 I1_I884_G29_14n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I180_XG_MP0 (VDD I1_I884_P29_22 XI1_I884_I180_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I180_XG_MP1 (XI1_I884_I180_XG_p1 I1_I884_G21_14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I174_XG_MP2 (XI1_I884_I174_XG_p1 I1_I884_G23_16 I1_I884_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I174_XG_MP0 (VDD I1_I884_P23_16 XI1_I884_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I174_XG_MP1 (XI1_I884_I174_XG_p1 I1_I884_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I166_XG_MP2 (XI1_I884_I166_XG_p1 I1_I884_G15_8 I1_I884_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I166_XG_MP0 (VDD I1_I884_P15_8 XI1_I884_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I166_XG_MP1 (XI1_I884_I166_XG_p1 I1_I884_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I176_XG_MP2 (XI1_I884_I176_XG_p1 I1_I884_G25_18 I1_I884_G25_10n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I176_XG_MP0 (VDD I1_I884_P25_18 XI1_I884_I176_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I176_XG_MP1 (XI1_I884_I176_XG_p1 I1_I884_G17_10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I172_XG_MP2 (XI1_I884_I172_XG_p1 I1_I884_G21_14 I1_I884_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I172_XG_MP0 (VDD I1_I884_P21_14 XI1_I884_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I172_XG_MP1 (XI1_I884_I172_XG_p1 I1_I884_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I170_XG_MP2 (XI1_I884_I170_XG_p1 I1_I884_G19_12 I1_I884_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I170_XG_MP0 (VDD I1_I884_P19_12 XI1_I884_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I170_XG_MP1 (XI1_I884_I170_XG_p1 I1_I884_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I162_XG_MP2 (XI1_I884_I162_XG_p1 I1_I884_G11_4 I1_I884_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I162_XG_MP0 (VDD I1_I884_P11_4 XI1_I884_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I162_XG_MP1 (XI1_I884_I162_XG_p1 I1_I884_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I164_XG_MP2 (XI1_I884_I164_XG_p1 I1_I884_G13_6 I1_I884_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I164_XG_MP0 (VDD I1_I884_P13_6 XI1_I884_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I164_XG_MP1 (XI1_I884_I164_XG_p1 I1_I884_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I107_XG_MP2 (XI1_I884_I107_XG_p1 I1_I884_G11_10 I1_I884_G11_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I107_XG_MP0 (VDD I1_I884_P11_10 XI1_I884_I107_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I107_XG_MP1 (XI1_I884_I107_XG_p1 I1_I884_G9_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I105_XG_MP2 (XI1_I884_I105_XG_p1 I1_I884_G9_8 I1_I884_G9_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I105_XG_MP0 (VDD I1_I884_P9_8 XI1_I884_I105_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I105_XG_MP1 (XI1_I884_I105_XG_p1 I1_I884_G7_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I99_XG_MP2 (XI1_I746_I99_XG_p1 I1_I746_G3_2 I1_I746_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I99_XG_MP0 (VDD I1_I746_P3_2 XI1_I746_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I99_XG_MP1 (XI1_I746_I99_XG_p1 I1_I746_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I157_XG_MP2 (XI1_I1298_I157_XG_p1 I1_I1298_G8_1 I1_I1298_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I157_XG_MP0 (VDD I1_I1298_P8_1 XI1_I1298_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I157_XG_MP1 (XI1_I1298_I157_XG_p1 I1_I1298_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I102_XG_MP2 (XI1_I1298_I102_XG_p1 I1_I1298_G6_5 I1_I1298_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I102_XG_MP0 (VDD I1_I1298_P6_5 XI1_I1298_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I102_XG_MP1 (XI1_I1298_I102_XG_p1 I1_I1298_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I104_XG_MP2 (XI1_I1298_I104_XG_p1 I1_I1298_G8_7 I1_I1298_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I104_XG_MP0 (VDD I1_I1298_P8_7 XI1_I1298_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I104_XG_MP1 (XI1_I1298_I104_XG_p1 I1_I1298_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I104_XG_MP2 (XI1_I1252_I104_XG_p1 I1_I1252_G8_7 I1_I1252_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I104_XG_MP0 (VDD I1_I1252_P8_7 XI1_I1252_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I104_XG_MP1 (XI1_I1252_I104_XG_p1 I1_I1252_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I103_XG_MP2 (XI1_I1252_I103_XG_p1 I1_I1252_G7_6 I1_I1252_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I103_XG_MP0 (VDD I1_I1252_P7_6 XI1_I1252_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I103_XG_MP1 (XI1_I1252_I103_XG_p1 I1_I1252_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I101_XG_MP2 (XI1_I1206_I101_XG_p1 I1_I1206_G5_4 I1_I1206_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I101_XG_MP0 (VDD I1_I1206_P5_4 XI1_I1206_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I101_XG_MP1 (XI1_I1206_I101_XG_p1 I1_I1206_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I99_XG_MP2 (XI1_I1206_I99_XG_p1 I1_I1206_G3_2 I1_I1206_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I99_XG_MP0 (VDD I1_I1206_P3_2 XI1_I1206_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I99_XG_MP1 (XI1_I1206_I99_XG_p1 I1_I1206_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I102_XG_MP2 (XI1_I1206_I102_XG_p1 I1_I1206_G6_5 I1_I1206_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I102_XG_MP0 (VDD I1_I1206_P6_5 XI1_I1206_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I102_XG_MP1 (XI1_I1206_I102_XG_p1 I1_I1206_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I157_XG_MP2 (XI1_I1206_I157_XG_p1 I1_I1206_G8_1 I1_I1206_G8_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I157_XG_MP0 (VDD I1_I1206_P8_1 XI1_I1206_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I157_XG_MP1 (XI1_I1206_I157_XG_p1 I1_I1206_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I126_XG_MP2 (XI1_I884_I126_XG_p1 I1_I884_G30_29 I1_I884_G30_27n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I126_XG_MP0 (VDD I1_I884_P30_29 XI1_I884_I126_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I126_XG_MP1 (XI1_I884_I126_XG_p1 I1_I884_G28_27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I124_XG_MP2 (XI1_I884_I124_XG_p1 I1_I884_G28_27 I1_I884_G28_25n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I124_XG_MP0 (VDD I1_I884_P28_27 XI1_I884_I124_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I124_XG_MP1 (XI1_I884_I124_XG_p1 I1_I884_G26_25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I122_XG_MP2 (XI1_I884_I122_XG_p1 I1_I884_G26_25 I1_I884_G26_23n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I122_XG_MP0 (VDD I1_I884_P26_25 XI1_I884_I122_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I122_XG_MP1 (XI1_I884_I122_XG_p1 I1_I884_G24_23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I116_XG_MP2 (XI1_I884_I116_XG_p1 I1_I884_G20_19 I1_I884_G20_17n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I116_XG_MP0 (VDD I1_I884_P20_19 XI1_I884_I116_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I116_XG_MP1 (XI1_I884_I116_XG_p1 I1_I884_G18_17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I168_XG_MP2 (XI1_I884_I168_XG_p1 I1_I884_G17_10 I1_I884_G17_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I168_XG_MP0 (VDD I1_I884_P17_10 XI1_I884_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I168_XG_MP1 (XI1_I884_I168_XG_p1 I1_I884_G9_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I158_XG_MP2 (XI1_I884_I158_XG_p1 I1_I884_G9_2 I1_I884_G9_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I158_XG_MP0 (VDD I1_I884_P9_2 XI1_I884_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I158_XG_MP1 (XI1_I884_I158_XG_p1 I1_I884_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I103_XG_MP2 (XI1_I884_I103_XG_p1 I1_I884_G7_6 I1_I884_G7_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I103_XG_MP0 (VDD I1_I884_P7_6 XI1_I884_I103_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I103_XG_MP1 (XI1_I884_I103_XG_p1 I1_I884_G5_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I166_XG_MP2 (XI1_I700_I166_XG_p1 I1_I700_G15_8 I1_I700_G15_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I166_XG_MP0 (VDD I1_I700_P15_8 XI1_I700_I166_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I166_XG_MP1 (XI1_I700_I166_XG_p1 I1_I700_G7_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I123_XG_MP2 (XI1_I1390_I123_XG_p1 I1_I1390_G27_26 I1_I1390_G27_24n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I123_XG_MP0 (VDD I1_I1390_P27_26 XI1_I1390_I123_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I123_XG_MP1 (XI1_I1390_I123_XG_p1 I1_I1390_G25_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I121_XG_MP2 (XI1_I1390_I121_XG_p1 I1_I1390_G25_24 I1_I1390_G25_22n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I121_XG_MP0 (VDD I1_I1390_P25_24 XI1_I1390_I121_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I121_XG_MP1 (XI1_I1390_I121_XG_p1 I1_I1390_G23_22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I119_XG_MP2 (XI1_I1390_I119_XG_p1 I1_I1390_G23_22 I1_I1390_G23_20n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I119_XG_MP0 (VDD I1_I1390_P23_22 XI1_I1390_I119_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I119_XG_MP1 (XI1_I1390_I119_XG_p1 I1_I1390_G21_20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I102_XG_MP2 (XI1_I1344_I102_XG_p1 I1_I1344_G6_5 I1_I1344_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I102_XG_MP0 (VDD I1_I1344_P6_5 XI1_I1344_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I102_XG_MP1 (XI1_I1344_I102_XG_p1 I1_I1344_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I98_XG_MP2 (XI1_I1252_I98_XG_p1 I1_I1252_G2_1 I1_I1252_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I98_XG_MP0 (VDD I1_I1252_P2_1 XI1_I1252_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I98_XG_MP1 (XI1_I1252_I98_XG_p1 I1_I1252_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I100_XG_MP2 (XI1_I1252_I100_XG_p1 I1_I1252_G4_3 I1_I1252_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I100_XG_MP0 (VDD I1_I1252_P4_3 XI1_I1252_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I100_XG_MP1 (XI1_I1252_I100_XG_p1 I1_I1252_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I102_XG_MP2 (XI1_I1252_I102_XG_p1 I1_I1252_G6_5 I1_I1252_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I102_XG_MP0 (VDD I1_I1252_P6_5 XI1_I1252_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I102_XG_MP1 (XI1_I1252_I102_XG_p1 I1_I1252_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I99_XG_MP2 (XI1_I1252_I99_XG_p1 I1_I1252_G3_2 I1_I1252_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I99_XG_MP0 (VDD I1_I1252_P3_2 XI1_I1252_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I99_XG_MP1 (XI1_I1252_I99_XG_p1 I1_I1252_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I101_XG_MP2 (XI1_I1252_I101_XG_p1 I1_I1252_G5_4 I1_I1252_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I101_XG_MP0 (VDD I1_I1252_P5_4 XI1_I1252_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I101_XG_MP1 (XI1_I1252_I101_XG_p1 I1_I1252_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I178_XG_MP2 (XI1_I1160_I178_XG_p1 I1_I1160_G27_20 I1_I1160_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I178_XG_MP0 (VDD I1_I1160_P27_20 XI1_I1160_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I178_XG_MP1 (XI1_I1160_I178_XG_p1 I1_I1160_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I170_XG_MP2 (XI1_I1160_I170_XG_p1 I1_I1160_G19_12 I1_I1160_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I170_XG_MP0 (VDD I1_I1160_P19_12 XI1_I1160_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I170_XG_MP1 (XI1_I1160_I170_XG_p1 I1_I1160_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I162_XG_MP2 (XI1_I1160_I162_XG_p1 I1_I1160_G11_4 I1_I1160_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1160_I162_XG_MP0 (VDD I1_I1160_P11_4 XI1_I1160_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1160_I162_XG_MP1 (XI1_I1160_I162_XG_p1 I1_I1160_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I98_XG_MP2 (XI1_I1206_I98_XG_p1 I1_I1206_G2_1 I1_I1206_G2_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I98_XG_MP0 (VDD I1_I1206_P2_1 XI1_I1206_I98_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I98_XG_MP1 (XI1_I1206_I98_XG_p1 I1_I1206_G0_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I100_XG_MP2 (XI1_I1206_I100_XG_p1 I1_I1206_G4_3 I1_I1206_G4_1n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I100_XG_MP0 (VDD I1_I1206_P4_3 XI1_I1206_I100_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I100_XG_MP1 (XI1_I1206_I100_XG_p1 I1_I1206_G2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I181_XG_MP2 (XI1_I884_I181_XG_p1 I1_I884_G30_23 I1_I884_G30_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I181_XG_MP0 (VDD I1_I884_P30_23 XI1_I884_I181_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I181_XG_MP1 (XI1_I884_I181_XG_p1 I1_I884_G22_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I177_XG_MP2 (XI1_I884_I177_XG_p1 I1_I884_G26_19 I1_I884_G26_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I177_XG_MP0 (VDD I1_I884_P26_19 XI1_I884_I177_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I177_XG_MP1 (XI1_I884_I177_XG_p1 I1_I884_G18_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I173_XG_MP2 (XI1_I884_I173_XG_p1 I1_I884_G22_15 I1_I884_G22_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I173_XG_MP0 (VDD I1_I884_P22_15 XI1_I884_I173_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I173_XG_MP1 (XI1_I884_I173_XG_p1 I1_I884_G14_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I165_XG_MP2 (XI1_I884_I165_XG_p1 I1_I884_G14_7 I1_I884_G14_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I165_XG_MP0 (VDD I1_I884_P14_7 XI1_I884_I165_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I165_XG_MP1 (XI1_I884_I165_XG_p1 I1_I884_G6_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I175_XG_MP2 (XI1_I884_I175_XG_p1 I1_I884_G24_17 I1_I884_G24_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I175_XG_MP0 (VDD I1_I884_P24_17 XI1_I884_I175_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I175_XG_MP1 (XI1_I884_I175_XG_p1 I1_I884_G16_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I114_XG_MP2 (XI1_I884_I114_XG_p1 I1_I884_G18_17 I1_I884_G18_15n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I114_XG_MP0 (VDD I1_I884_P18_17 XI1_I884_I114_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I114_XG_MP1 (XI1_I884_I114_XG_p1 I1_I884_G16_15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I112_XG_MP2 (XI1_I884_I112_XG_p1 I1_I884_G16_15 I1_I884_G16_13n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I112_XG_MP0 (VDD I1_I884_P16_15 XI1_I884_I112_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I112_XG_MP1 (XI1_I884_I112_XG_p1 I1_I884_G14_13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I110_XG_MP2 (XI1_I884_I110_XG_p1 I1_I884_G14_13 I1_I884_G14_11n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I110_XG_MP0 (VDD I1_I884_P14_13 XI1_I884_I110_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I110_XG_MP1 (XI1_I884_I110_XG_p1 I1_I884_G12_11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I108_XG_MP2 (XI1_I884_I108_XG_p1 I1_I884_G12_11 I1_I884_G12_9n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I108_XG_MP0 (VDD I1_I884_P12_11 XI1_I884_I108_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I108_XG_MP1 (XI1_I884_I108_XG_p1 I1_I884_G10_9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I106_XG_MP2 (XI1_I884_I106_XG_p1 I1_I884_G10_9 I1_I884_G10_7n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I106_XG_MP0 (VDD I1_I884_P10_9 XI1_I884_I106_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I106_XG_MP1 (XI1_I884_I106_XG_p1 I1_I884_G8_7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I104_XG_MP2 (XI1_I884_I104_XG_p1 I1_I884_G8_7 I1_I884_G8_5n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I104_XG_MP0 (VDD I1_I884_P8_7 XI1_I884_I104_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I104_XG_MP1 (XI1_I884_I104_XG_p1 I1_I884_G6_5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I102_XG_MP2 (XI1_I884_I102_XG_p1 I1_I884_G6_5 I1_I884_G6_3n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I102_XG_MP0 (VDD I1_I884_P6_5 XI1_I884_I102_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I102_XG_MP1 (XI1_I884_I102_XG_p1 I1_I884_G4_3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I101_XG_MP2 (XI1_I884_I101_XG_p1 I1_I884_G5_4 I1_I884_G5_2n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I101_XG_MP0 (VDD I1_I884_P5_4 XI1_I884_I101_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I101_XG_MP1 (XI1_I884_I101_XG_p1 I1_I884_G3_2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I99_XG_MP2 (XI1_I884_I99_XG_p1 I1_I884_G3_2 I1_I884_G3_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I99_XG_MP0 (VDD I1_I884_P3_2 XI1_I884_I99_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I99_XG_MP1 (XI1_I884_I99_XG_p1 I1_I884_G1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I162_XG_MP2 (XI1_I700_I162_XG_p1 I1_I700_G11_4 I1_I700_G11_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I162_XG_MP0 (VDD I1_I700_P11_4 XI1_I700_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I162_XG_MP1 (XI1_I700_I162_XG_p1 I1_I700_G3_0np VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I164_XG_MP2 (XI1_I700_I164_XG_p1 I1_I700_G13_6 I1_I700_G13_0n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I164_XG_MP0 (VDD I1_I700_P13_6 XI1_I700_I164_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I164_XG_MP1 (XI1_I700_I164_XG_p1 I1_I700_G5_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I170_XG_MP2 (XI1_I700_I170_XG_p1 I1_I700_G19_12 I1_I700_G19_4n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I170_XG_MP0 (VDD I1_I700_P19_12 XI1_I700_I170_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I170_XG_MP1 (XI1_I700_I170_XG_p1 I1_I700_G11_4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I172_XG_MP2 (XI1_I700_I172_XG_p1 I1_I700_G21_14 I1_I700_G21_6n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I172_XG_MP0 (VDD I1_I700_P21_14 XI1_I700_I172_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I172_XG_MP1 (XI1_I700_I172_XG_p1 I1_I700_G13_6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I178_XG_MP2 (XI1_I700_I178_XG_p1 I1_I700_G27_20 I1_I700_G27_12n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I178_XG_MP0 (VDD I1_I700_P27_20 XI1_I700_I178_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I178_XG_MP1 (XI1_I700_I178_XG_p1 I1_I700_G19_12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I174_XG_MP2 (XI1_I700_I174_XG_p1 I1_I700_G23_16 I1_I700_G23_8n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I174_XG_MP0 (VDD I1_I700_P23_16 XI1_I700_I174_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I174_XG_MP1 (XI1_I700_I174_XG_p1 I1_I700_G15_8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I182_XG_MP2 (XI1_I700_I182_XG_p1 I1_I700_G31_24 I1_I700_G31_16n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I182_XG_MP0 (VDD I1_I700_P31_24 XI1_I700_I182_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I700_I182_XG_MP1 (XI1_I700_I182_XG_p1 I1_I700_G23_16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I127_XG_MP2 (XI1_I1390_I127_XG_p1 I1_I1390_G31_30 I1_I1390_G31_28n VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I127_XG_MP0 (VDD I1_I1390_P31_30 XI1_I1390_I127_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
