    I_MXI1_I1160_I140_XG_MP2 (VDD I1_I1160_G15_12n I1_I1160_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I140_XG_MP0 (XI1_I1160_I140_XG_p1 I1_I1160_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I140_XG_MP1 (I1_I1160_G15_8 I1_I1160_G11_8n XI1_I1160_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I72_XG_MP2 (VDD I1_I1390_gn6 I1_I1390_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1390_I72_XG_MP0 (XI1_I1390_I72_XG_p1 I1_I1390_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1390_I72_XG_MP1 (I1_I1390_G6_5 I1_I1390_gn5 XI1_I1390_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I71_XG_MP2 (VDD I1_I1390_gn5 I1_I1390_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1390_I71_XG_MP0 (XI1_I1390_I71_XG_p1 I1_I1390_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1390_I71_XG_MP1 (I1_I1390_G5_4 I1_I1390_gn4 XI1_I1390_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I135_XG_MP2 (VDD I1_I1160_G10_7n I1_I1160_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I135_XG_MP0 (XI1_I1160_I135_XG_p1 I1_I1160_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I135_XG_MP1 (I1_I1160_G10_3 I1_I1160_G6_3n XI1_I1160_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I141_XG_MP2 (VDD I1_I1160_G16_13n I1_I1160_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I141_XG_MP0 (XI1_I1160_I141_XG_p1 I1_I1160_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I141_XG_MP1 (I1_I1160_G16_9 I1_I1160_G12_9n XI1_I1160_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I137_XG_MP2 (VDD I1_I1160_G12_9n I1_I1160_G12_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I137_XG_MP0 (XI1_I1160_I137_XG_p1 I1_I1160_P12_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I137_XG_MP1 (I1_I1160_G12_5 I1_I1160_G8_5n XI1_I1160_I137_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I85_XG_MP2 (VDD I1_I1160_gn19 I1_I1160_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I85_XG_MP0 (XI1_I1160_I85_XG_p1 I1_I1160_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I85_XG_MP1 (I1_I1160_G19_18 I1_I1160_gn18 XI1_I1160_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I84_XG_MP2 (VDD I1_I1160_gn18 I1_I1160_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I84_XG_MP0 (XI1_I1160_I84_XG_p1 I1_I1160_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I84_XG_MP1 (I1_I1160_G18_17 I1_I1160_gn17 XI1_I1160_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I97_XG_MP2 (VDD I1_I976_gn31 I1_I976_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I976_I97_XG_MP0 (XI1_I976_I97_XG_p1 I1_I976_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I976_I97_XG_MP1 (I1_I976_G31_30 I1_I976_gn30 XI1_I976_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I95_XG_MP2 (VDD I1_I976_gn29 I1_I976_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I976_I95_XG_MP0 (XI1_I976_I95_XG_p1 I1_I976_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I976_I95_XG_MP1 (I1_I976_G29_28 I1_I976_gn28 XI1_I976_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I149_XG_MP2 (VDD I1_I976_G24_21n I1_I976_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I976_I149_XG_MP0 (XI1_I976_I149_XG_p1 I1_I976_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I976_I149_XG_MP1 (I1_I976_G24_17 I1_I976_G20_17n XI1_I976_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I145_XG_MP2 (VDD I1_I976_G20_17n I1_I976_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I976_I145_XG_MP0 (XI1_I976_I145_XG_p1 I1_I976_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I976_I145_XG_MP1 (I1_I976_G20_13 I1_I976_G16_13n XI1_I976_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I135_XG_MP2 (VDD I1_I1114_G10_7n I1_I1114_G10_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1114_I135_XG_MP0 (XI1_I1114_I135_XG_p1 I1_I1114_P10_7n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1114_I135_XG_MP1 (I1_I1114_G10_3 I1_I1114_G6_3n XI1_I1114_I135_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I131_XG_MP2 (VDD I1_I1114_G6_3n I1_I1114_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1114_I131_XG_MP0 (XI1_I1114_I131_XG_p1 I1_I1114_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1114_I131_XG_MP1 (I1_I1114_G6_0 I1_I1114_G2_0n XI1_I1114_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I145_XG_MP2 (VDD I1_I1528_G20_17n I1_I1528_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1528_I145_XG_MP0 (XI1_I1528_I145_XG_p1 I1_I1528_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1528_I145_XG_MP1 (I1_I1528_G20_13 I1_I1528_G16_13n XI1_I1528_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I143_XG_MP2 (VDD I1_I1528_G18_15n I1_I1528_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1528_I143_XG_MP0 (XI1_I1528_I143_XG_p1 I1_I1528_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1528_I143_XG_MP1 (I1_I1528_G18_11 I1_I1528_G14_11n XI1_I1528_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I84_XG_MP2 (VDD I1_I1712_gn18 I1_I1712_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1712_I84_XG_MP0 (XI1_I1712_I84_XG_p1 I1_I1712_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1712_I84_XG_MP1 (I1_I1712_G18_17 I1_I1712_gn17 XI1_I1712_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I83_XG_MP2 (VDD I1_I1712_gn17 I1_I1712_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1712_I83_XG_MP0 (XI1_I1712_I83_XG_p1 I1_I1712_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1712_I83_XG_MP1 (I1_I1712_G17_16 I1_I1712_gn16 XI1_I1712_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I82_XG_MP2 (VDD I1_I1712_gn16 I1_I1712_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1712_I82_XG_MP0 (XI1_I1712_I82_XG_p1 I1_I1712_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1712_I82_XG_MP1 (I1_I1712_G16_15 I1_I1712_gn15 XI1_I1712_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I152_XG_MP2 (VDD I1_I1666_G27_24n I1_I1666_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1666_I152_XG_MP0 (XI1_I1666_I152_XG_p1 I1_I1666_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1666_I152_XG_MP1 (I1_I1666_G27_20 I1_I1666_G23_20n XI1_I1666_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I148_XG_MP2 (VDD I1_I1666_G23_20n I1_I1666_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1666_I148_XG_MP0 (XI1_I1666_I148_XG_p1 I1_I1666_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1666_I148_XG_MP1 (I1_I1666_G23_16 I1_I1666_G19_16n XI1_I1666_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I83_XG_MP2 (VDD I1_I1850_gn17 I1_I1850_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1850_I83_XG_MP0 (XI1_I1850_I83_XG_p1 I1_I1850_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1850_I83_XG_MP1 (I1_I1850_G17_16 I1_I1850_gn16 XI1_I1850_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I82_XG_MP2 (VDD I1_I1850_gn16 I1_I1850_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1850_I82_XG_MP0 (XI1_I1850_I82_XG_p1 I1_I1850_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1850_I82_XG_MP1 (I1_I1850_G16_15 I1_I1850_gn15 XI1_I1850_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I82_XG_MP2 (VDD I1_I838_gn16 I1_I838_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I838_I82_XG_MP0 (XI1_I838_I82_XG_p1 I1_I838_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I838_I82_XG_MP1 (I1_I838_G16_15 I1_I838_gn15 XI1_I838_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I81_XG_MP2 (VDD I1_I838_gn15 I1_I838_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I838_I81_XG_MP0 (XI1_I838_I81_XG_p1 I1_I838_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I838_I81_XG_MP1 (I1_I838_G15_14 I1_I838_gn14 XI1_I838_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I88_XG_MP2 (VDD I1_I884_gn22 I1_I884_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I884_I88_XG_MP0 (XI1_I884_I88_XG_p1 I1_I884_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I884_I88_XG_MP1 (I1_I884_G22_21 I1_I884_gn21 XI1_I884_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I87_XG_MP2 (VDD I1_I884_gn21 I1_I884_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I884_I87_XG_MP0 (XI1_I884_I87_XG_p1 I1_I884_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I884_I87_XG_MP1 (I1_I884_G21_20 I1_I884_gn20 XI1_I884_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I91_XG_MP2 (VDD I1_I1436_gn25 I1_I1436_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1436_I91_XG_MP0 (XI1_I1436_I91_XG_p1 I1_I1436_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1436_I91_XG_MP1 (I1_I1436_G25_24 I1_I1436_gn24 XI1_I1436_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I90_XG_MP2 (VDD I1_I1436_gn24 I1_I1436_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1436_I90_XG_MP0 (XI1_I1436_I90_XG_p1 I1_I1436_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1436_I90_XG_MP1 (I1_I1436_G24_23 I1_I1436_gn23 XI1_I1436_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I89_XG_MP2 (VDD I1_I1436_gn23 I1_I1436_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1436_I89_XG_MP0 (XI1_I1436_I89_XG_p1 I1_I1436_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1436_I89_XG_MP1 (I1_I1436_G23_22 I1_I1436_gn22 XI1_I1436_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I88_XG_MP2 (VDD I1_I1436_gn22 I1_I1436_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1436_I88_XG_MP0 (XI1_I1436_I88_XG_p1 I1_I1436_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1436_I88_XG_MP1 (I1_I1436_G22_21 I1_I1436_gn21 XI1_I1436_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I76_XG_MP2 (VDD I1_I1436_gn10 I1_I1436_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1436_I76_XG_MP0 (XI1_I1436_I76_XG_p1 I1_I1436_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1436_I76_XG_MP1 (I1_I1436_G10_9 I1_I1436_gn9 XI1_I1436_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I75_XG_MP2 (VDD I1_I1436_gn9 I1_I1436_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1436_I75_XG_MP0 (XI1_I1436_I75_XG_p1 I1_I1436_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1436_I75_XG_MP1 (I1_I1436_G9_8 I1_I1436_gn8 XI1_I1436_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I145_XG_MP2 (VDD I1_I1436_G20_17n I1_I1436_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1436_I145_XG_MP0 (XI1_I1436_I145_XG_p1 I1_I1436_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1436_I145_XG_MP1 (I1_I1436_G20_13 I1_I1436_G16_13n XI1_I1436_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I143_XG_MP2 (VDD I1_I1436_G18_15n I1_I1436_G18_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1436_I143_XG_MP0 (XI1_I1436_I143_XG_p1 I1_I1436_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1436_I143_XG_MP1 (I1_I1436_G18_11 I1_I1436_G14_11n XI1_I1436_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I91_XG_MP2 (VDD I1_I976_gn25 I1_I976_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I976_I91_XG_MP0 (XI1_I976_I91_XG_p1 I1_I976_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I976_I91_XG_MP1 (I1_I976_G25_24 I1_I976_gn24 XI1_I976_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I90_XG_MP2 (VDD I1_I976_gn24 I1_I976_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I976_I90_XG_MP0 (XI1_I976_I90_XG_p1 I1_I976_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I976_I90_XG_MP1 (I1_I976_G24_23 I1_I976_gn23 XI1_I976_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I82_XG_MP2 (VDD I1_I1482_gn16 I1_I1482_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1482_I82_XG_MP0 (XI1_I1482_I82_XG_p1 I1_I1482_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1482_I82_XG_MP1 (I1_I1482_G16_15 I1_I1482_gn15 XI1_I1482_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I81_XG_MP2 (VDD I1_I1482_gn15 I1_I1482_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1482_I81_XG_MP0 (XI1_I1482_I81_XG_p1 I1_I1482_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1482_I81_XG_MP1 (I1_I1482_G15_14 I1_I1482_gn14 XI1_I1482_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I80_XG_MP2 (VDD I1_I1482_gn14 I1_I1482_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1482_I80_XG_MP0 (XI1_I1482_I80_XG_p1 I1_I1482_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1482_I80_XG_MP1 (I1_I1482_G14_13 I1_I1482_gn13 XI1_I1482_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I72_XG_MP2 (VDD I1_I1528_gn6 I1_I1528_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1528_I72_XG_MP0 (XI1_I1528_I72_XG_p1 I1_I1528_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1528_I72_XG_MP1 (I1_I1528_G6_5 I1_I1528_gn5 XI1_I1528_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I71_XG_MP2 (VDD I1_I1528_gn5 I1_I1528_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1528_I71_XG_MP0 (XI1_I1528_I71_XG_p1 I1_I1528_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1528_I71_XG_MP1 (I1_I1528_G5_4 I1_I1528_gn4 XI1_I1528_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I139_XG_MP2 (VDD I1_I1574_G14_11n I1_I1574_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1574_I139_XG_MP0 (XI1_I1574_I139_XG_p1 I1_I1574_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1574_I139_XG_MP1 (I1_I1574_G14_7 I1_I1574_G10_7n XI1_I1574_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1574_I195_XG_MP2 (VDD I1_I1574_G24_9n I1_I1574_G24_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1574_I195_XG_MP0 (XI1_I1574_I195_XG_p1 I1_I1574_P24_9n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1574_I195_XG_MP1 (I1_I1574_G24_0 I1_I1574_G8_0n XI1_I1574_I195_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I68_XG_MP2 (VDD I2_I1_I42_gn2 I2_I1_I42_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2_I1_I42_I68_XG_MP0 (XI2_I1_I42_I68_XG_p1 I2_I1_I42_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I68_XG_MP1 (I2_I1_I42_G2_1 I2_I1_I42_gn1 XI2_I1_I42_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I67_XG_MP2 (VDD I2_I1_I42_gn1 I2_I1_I42_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2_I1_I42_I67_XG_MP0 (XI2_I1_I42_I67_XG_p1 I2_I1_I42_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I67_XG_MP1 (I2_I1_I42_G1_0 I2_I1_I42_G0_0n XI2_I1_I42_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I87_XG_MP2 (VDD I1_I1758_gn21 I1_I1758_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1758_I87_XG_MP0 (XI1_I1758_I87_XG_p1 I1_I1758_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1758_I87_XG_MP1 (I1_I1758_G21_20 I1_I1758_gn20 XI1_I1758_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I86_XG_MP2 (VDD I1_I1758_gn20 I1_I1758_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1758_I86_XG_MP0 (XI1_I1758_I86_XG_p1 I1_I1758_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1758_I86_XG_MP1 (I1_I1758_G20_19 I1_I1758_gn19 XI1_I1758_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I93_XG_MP2 (VDD I1_I838_gn27 I1_I838_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I838_I93_XG_MP0 (XI1_I838_I93_XG_p1 I1_I838_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I838_I93_XG_MP1 (I1_I838_G27_26 I1_I838_gn26 XI1_I838_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I92_XG_MP2 (VDD I1_I838_gn26 I1_I838_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I838_I92_XG_MP0 (XI1_I838_I92_XG_p1 I1_I838_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I838_I92_XG_MP1 (I1_I838_G26_25 I1_I838_gn25 XI1_I838_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I202_XG_MP2 (VDD I1_I1114_G31_16n I1_c12_o VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1114_I202_XG_MP0 (XI1_I1114_I202_XG_p1 I1_I1114_P31_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1114_I202_XG_MP1 (I1_c12_o I1_I1114_G15_0n XI1_I1114_I202_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I154_XG_MP2 (VDD I1_I1114_G29_26n I1_I1114_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1114_I154_XG_MP0 (XI1_I1114_I154_XG_p1 I1_I1114_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1114_I154_XG_MP1 (I1_I1114_G29_22 I1_I1114_G25_22n XI1_I1114_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I82_XG_MP2 (VDD I1_I976_gn16 I1_I976_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I976_I82_XG_MP0 (XI1_I976_I82_XG_p1 I1_I976_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I976_I82_XG_MP1 (I1_I976_G16_15 I1_I976_gn15 XI1_I976_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I81_XG_MP2 (VDD I1_I976_gn15 I1_I976_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I976_I81_XG_MP0 (XI1_I976_I81_XG_p1 I1_I976_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I976_I81_XG_MP1 (I1_I976_G15_14 I1_I976_gn14 XI1_I976_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I80_XG_MP2 (VDD I1_I976_gn14 I1_I976_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I976_I80_XG_MP0 (XI1_I976_I80_XG_p1 I1_I976_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I976_I80_XG_MP1 (I1_I976_G14_13 I1_I976_gn13 XI1_I976_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I140_XG_MP2 (VDD I1_I1482_G15_12n I1_I1482_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1482_I140_XG_MP0 (XI1_I1482_I140_XG_p1 I1_I1482_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1482_I140_XG_MP1 (I1_I1482_G15_8 I1_I1482_G11_8n XI1_I1482_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I142_XG_MP2 (VDD I1_I1482_G17_14n I1_I1482_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1482_I142_XG_MP0 (XI1_I1482_I142_XG_p1 I1_I1482_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1482_I142_XG_MP1 (I1_I1482_G17_10 I1_I1482_G13_10n XI1_I1482_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I82_XG_MP2 (VDD I1_I1528_gn16 I1_I1528_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1528_I82_XG_MP0 (XI1_I1528_I82_XG_p1 I1_I1528_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1528_I82_XG_MP1 (I1_I1528_G16_15 I1_I1528_gn15 XI1_I1528_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I81_XG_MP2 (VDD I1_I1528_gn15 I1_I1528_G15_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1528_I81_XG_MP0 (XI1_I1528_I81_XG_p1 I1_I1528_pn15 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1528_I81_XG_MP1 (I1_I1528_G15_14 I1_I1528_gn14 XI1_I1528_I81_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I82_XG_MP2 (VDD I1_I1758_gn16 I1_I1758_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1758_I82_XG_MP0 (XI1_I1758_I82_XG_p1 I1_I1758_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1758_I82_XG_MP1 (I1_I1758_G16_15 I1_I1758_gn15 XI1_I1758_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I80_XG_MP2 (VDD I1_I1758_gn14 I1_I1758_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1758_I80_XG_MP0 (XI1_I1758_I80_XG_p1 I1_I1758_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1758_I80_XG_MP1 (I1_I1758_G14_13 I1_I1758_gn13 XI1_I1758_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I78_XG_MP2 (VDD I1_I1758_gn12 I1_I1758_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1758_I78_XG_MP0 (XI1_I1758_I78_XG_p1 I1_I1758_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1758_I78_XG_MP1 (I1_I1758_G12_11 I1_I1758_gn11 XI1_I1758_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I139_XG_MP2 (VDD I1_I1758_G14_11n I1_I1758_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1758_I139_XG_MP0 (XI1_I1758_I139_XG_p1 I1_I1758_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1758_I139_XG_MP1 (I1_I1758_G14_7 I1_I1758_G10_7n XI1_I1758_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1758_I141_XG_MP2 (VDD I1_I1758_G16_13n I1_I1758_G16_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1758_I141_XG_MP0 (XI1_I1758_I141_XG_p1 I1_I1758_P16_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1758_I141_XG_MP1 (I1_I1758_G16_9 I1_I1758_G12_9n XI1_I1758_I141_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I198_XG_MP2 (VDD I1_I1344_G27_12n I1_I1344_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1344_I198_XG_MP0 (XI1_I1344_I198_XG_p1 I1_I1344_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1344_I198_XG_MP1 (I1_I1344_G27_0 I1_I1344_G11_0n XI1_I1344_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I144_XG_MP2 (VDD I1_I1344_G19_16n I1_I1344_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1344_I144_XG_MP0 (XI1_I1344_I144_XG_p1 I1_I1344_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1344_I144_XG_MP1 (I1_I1344_G19_12 I1_I1344_G15_12n XI1_I1344_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I136_XG_MP2 (VDD I1_I1206_G11_8n I1_I1206_G11_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1206_I136_XG_MP0 (XI1_I1206_I136_XG_p1 I1_I1206_P11_8n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1206_I136_XG_MP1 (I1_I1206_G11_4 I1_I1206_G7_4n XI1_I1206_I136_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I138_XG_MP2 (VDD I1_I1206_G13_10n I1_I1206_G13_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1206_I138_XG_MP0 (XI1_I1206_I138_XG_p1 I1_I1206_P13_10n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1206_I138_XG_MP1 (I1_I1206_G13_6 I1_I1206_G9_6n XI1_I1206_I138_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I146_XG_MP2 (VDD I1_I884_G21_18n I1_I884_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I884_I146_XG_MP0 (XI1_I884_I146_XG_p1 I1_I884_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I884_I146_XG_MP1 (I1_I884_G21_14 I1_I884_G17_14n XI1_I884_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I144_XG_MP2 (VDD I1_I884_G19_16n I1_I884_G19_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I884_I144_XG_MP0 (XI1_I884_I144_XG_p1 I1_I884_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I884_I144_XG_MP1 (I1_I884_G19_12 I1_I884_G15_12n XI1_I884_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I85_XG_MP2 (VDD I1_I930_gn19 I1_I930_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I930_I85_XG_MP0 (XI1_I930_I85_XG_p1 I1_I930_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I930_I85_XG_MP1 (I1_I930_G19_18 I1_I930_gn18 XI1_I930_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I83_XG_MP2 (VDD I1_I930_gn17 I1_I930_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I930_I83_XG_MP0 (XI1_I930_I83_XG_p1 I1_I930_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I930_I83_XG_MP1 (I1_I930_G17_16 I1_I930_gn16 XI1_I930_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I82_XG_MP2 (VDD I1_I930_gn16 I1_I930_G16_15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I930_I82_XG_MP0 (XI1_I930_I82_XG_p1 I1_I930_pn16 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I930_I82_XG_MP1 (I1_I930_G16_15 I1_I930_gn15 XI1_I930_I82_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I75_XG_MP2 (VDD I1_I930_gn9 I1_I930_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I930_I75_XG_MP0 (XI1_I930_I75_XG_p1 I1_I930_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I930_I75_XG_MP1 (I1_I930_G9_8 I1_I930_gn8 XI1_I930_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I74_XG_MP2 (VDD I1_I930_gn8 I1_I930_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I930_I74_XG_MP0 (XI1_I930_I74_XG_p1 I1_I930_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I930_I74_XG_MP1 (I1_I930_G8_7 I1_I930_gn7 XI1_I930_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I79_XG_MP2 (VDD I1_I1160_gn13 I1_I1160_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I79_XG_MP0 (XI1_I1160_I79_XG_p1 I1_I1160_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I79_XG_MP1 (I1_I1160_G13_12 I1_I1160_gn12 XI1_I1160_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I77_XG_MP2 (VDD I1_I1160_gn11 I1_I1160_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I77_XG_MP0 (XI1_I1160_I77_XG_p1 I1_I1160_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I77_XG_MP1 (I1_I1160_G11_10 I1_I1160_gn10 XI1_I1160_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I75_XG_MP2 (VDD I1_I1160_gn9 I1_I1160_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I75_XG_MP0 (XI1_I1160_I75_XG_p1 I1_I1160_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I75_XG_MP1 (I1_I1160_G9_8 I1_I1160_gn8 XI1_I1160_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I74_XG_MP2 (VDD I1_I1160_gn8 I1_I1160_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I74_XG_MP0 (XI1_I1160_I74_XG_p1 I1_I1160_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I74_XG_MP1 (I1_I1160_G8_7 I1_I1160_gn7 XI1_I1160_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I76_XG_MP2 (VDD I1_I1482_gn10 I1_I1482_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1482_I76_XG_MP0 (XI1_I1482_I76_XG_p1 I1_I1482_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1482_I76_XG_MP1 (I1_I1482_G10_9 I1_I1482_gn9 XI1_I1482_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I75_XG_MP2 (VDD I1_I1482_gn9 I1_I1482_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1482_I75_XG_MP0 (XI1_I1482_I75_XG_p1 I1_I1482_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1482_I75_XG_MP1 (I1_I1482_G9_8 I1_I1482_gn8 XI1_I1482_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I71_XG_MP2 (VDD I1_I1482_gn5 I1_I1482_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1482_I71_XG_MP0 (XI1_I1482_I71_XG_p1 I1_I1482_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1482_I71_XG_MP1 (I1_I1482_G5_4 I1_I1482_gn4 XI1_I1482_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I70_XG_MP2 (VDD I1_I1482_gn4 I1_I1482_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1482_I70_XG_MP0 (XI1_I1482_I70_XG_p1 I1_I1482_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1482_I70_XG_MP1 (I1_I1482_G4_3 I1_I1482_gn3 XI1_I1482_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I79_XG_MP2 (VDD I1_I1022_gn13 I1_I1022_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1022_I79_XG_MP0 (XI1_I1022_I79_XG_p1 I1_I1022_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1022_I79_XG_MP1 (I1_I1022_G13_12 I1_I1022_gn12 XI1_I1022_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I78_XG_MP2 (VDD I1_I1022_gn12 I1_I1022_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1022_I78_XG_MP0 (XI1_I1022_I78_XG_p1 I1_I1022_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1022_I78_XG_MP1 (I1_I1022_G12_11 I1_I1022_gn11 XI1_I1022_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I72_XG_MP2 (VDD I1_I1114_gn6 I1_I1114_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1114_I72_XG_MP0 (XI1_I1114_I72_XG_p1 I1_I1114_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1114_I72_XG_MP1 (I1_I1114_G6_5 I1_I1114_gn5 XI1_I1114_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I71_XG_MP2 (VDD I1_I1114_gn5 I1_I1114_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1114_I71_XG_MP0 (XI1_I1114_I71_XG_p1 I1_I1114_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1114_I71_XG_MP1 (I1_I1114_G5_4 I1_I1114_gn4 XI1_I1114_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I70_XG_MP2 (VDD I1_I1114_gn4 I1_I1114_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1114_I70_XG_MP0 (XI1_I1114_I70_XG_p1 I1_I1114_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1114_I70_XG_MP1 (I1_I1114_G4_3 I1_I1114_gn3 XI1_I1114_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1114_I69_XG_MP2 (VDD I1_I1114_gn3 I1_I1114_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1114_I69_XG_MP0 (XI1_I1114_I69_XG_p1 I1_I1114_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1114_I69_XG_MP1 (I1_I1114_G3_2 I1_I1114_gn2 XI1_I1114_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I139_XG_MP2 (VDD I1_I1482_G14_11n I1_I1482_G14_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1482_I139_XG_MP0 (XI1_I1482_I139_XG_p1 I1_I1482_P14_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1482_I139_XG_MP1 (I1_I1482_G14_7 I1_I1482_G10_7n XI1_I1482_I139_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I188_XG_MP2 (VDD I1_I1482_G20_5n I1_I1482_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1482_I188_XG_MP0 (XI1_I1482_I188_XG_p1 I1_I1482_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1482_I188_XG_MP1 (I1_I1482_G20_0 I1_I1482_G4_0n XI1_I1482_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I197_XG_MP2 (VDD I1_I1528_G26_11n I1_I1528_G26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1528_I197_XG_MP0 (XI1_I1528_I197_XG_p1 I1_I1528_P26_11n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1528_I197_XG_MP1 (I1_I1528_G26_0 I1_I1528_G10_0n XI1_I1528_I197_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I188_XG_MP2 (VDD I1_I1528_G20_5n I1_I1528_G20_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1528_I188_XG_MP0 (XI1_I1528_I188_XG_p1 I1_I1528_P20_5n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1528_I188_XG_MP1 (I1_I1528_G20_0 I1_I1528_G4_0n XI1_I1528_I188_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I94_XG_MP2 (VDD I1_I1528_gn28 I1_I1528_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1528_I94_XG_MP0 (XI1_I1528_I94_XG_p1 I1_I1528_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1528_I94_XG_MP1 (I1_I1528_G28_27 I1_I1528_gn27 XI1_I1528_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I93_XG_MP2 (VDD I1_I1528_gn27 I1_I1528_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1528_I93_XG_MP0 (XI1_I1528_I93_XG_p1 I1_I1528_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1528_I93_XG_MP1 (I1_I1528_G27_26 I1_I1528_gn26 XI1_I1528_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I71_XG_MP2 (VDD I1_I1620_gn5 I1_I1620_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1620_I71_XG_MP0 (XI1_I1620_I71_XG_p1 I1_I1620_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1620_I71_XG_MP1 (I1_I1620_G5_4 I1_I1620_gn4 XI1_I1620_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I70_XG_MP2 (VDD I1_I1620_gn4 I1_I1620_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1620_I70_XG_MP0 (XI1_I1620_I70_XG_p1 I1_I1620_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1620_I70_XG_MP1 (I1_I1620_G4_3 I1_I1620_gn3 XI1_I1620_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I152_XG_MP2 (VDD I1_I1804_G27_24n I1_I1804_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1804_I152_XG_MP0 (XI1_I1804_I152_XG_p1 I1_I1804_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1804_I152_XG_MP1 (I1_I1804_G27_20 I1_I1804_G23_20n XI1_I1804_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I200_XG_MP2 (VDD I1_I1804_G29_14n I1_I1804_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1804_I200_XG_MP0 (XI1_I1804_I200_XG_p1 I1_I1804_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1804_I200_XG_MP1 (I1_I1804_G29_0 I1_I1804_G13_0n XI1_I1804_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I148_XG_MP2 (VDD I1_I1804_G23_20n I1_I1804_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1804_I148_XG_MP0 (XI1_I1804_I148_XG_p1 I1_I1804_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1804_I148_XG_MP1 (I1_I1804_G23_16 I1_I1804_G19_16n XI1_I1804_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I80_XG_MP2 (VDD I1_I1942_gn14 I1_I1942_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1942_I80_XG_MP0 (XI1_I1942_I80_XG_p1 I1_I1942_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1942_I80_XG_MP1 (I1_I1942_G14_13 I1_I1942_gn13 XI1_I1942_I80_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1942_I142_XG_MP2 (VDD I1_I1942_G17_14n I1_I1942_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1942_I142_XG_MP0 (XI1_I1942_I142_XG_p1 I1_I1942_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1942_I142_XG_MP1 (I1_I1942_G17_10 I1_I1942_G13_10n XI1_I1942_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I146_XG_MP2 (VDD I1_I1206_G21_18n I1_I1206_G21_14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1206_I146_XG_MP0 (XI1_I1206_I146_XG_p1 I1_I1206_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1206_I146_XG_MP1 (I1_I1206_G21_14 I1_I1206_G17_14n XI1_I1206_I146_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I190_XG_MP2 (VDD I1_I1206_G21_6n I1_I1206_G21_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1206_I190_XG_MP0 (XI1_I1206_I190_XG_p1 I1_I1206_P21_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1206_I190_XG_MP1 (I1_I1206_G21_0 I1_I1206_G5_0n XI1_I1206_I190_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I92_XG_MP2 (VDD I1_I1390_gn26 I1_I1390_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1390_I92_XG_MP0 (XI1_I1390_I92_XG_p1 I1_I1390_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1390_I92_XG_MP1 (I1_I1390_G26_25 I1_I1390_gn25 XI1_I1390_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I90_XG_MP2 (VDD I1_I1390_gn24 I1_I1390_G24_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1390_I90_XG_MP0 (XI1_I1390_I90_XG_p1 I1_I1390_pn24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1390_I90_XG_MP1 (I1_I1390_G24_23 I1_I1390_gn23 XI1_I1390_I90_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I72_XG_MP2 (VDD I1_I884_gn6 I1_I884_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I884_I72_XG_MP0 (XI1_I884_I72_XG_p1 I1_I884_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I884_I72_XG_MP1 (I1_I884_G6_5 I1_I884_gn5 XI1_I884_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I71_XG_MP2 (VDD I1_I884_gn5 I1_I884_G5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I884_I71_XG_MP0 (XI1_I884_I71_XG_p1 I1_I884_pn5 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I884_I71_XG_MP1 (I1_I884_G5_4 I1_I884_gn4 XI1_I884_I71_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I140_XG_MP2 (VDD I1_I1390_G15_12n I1_I1390_G15_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1390_I140_XG_MP0 (XI1_I1390_I140_XG_p1 I1_I1390_P15_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1390_I140_XG_MP1 (I1_I1390_G15_8 I1_I1390_G11_8n XI1_I1390_I140_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I142_XG_MP2 (VDD I1_I1390_G17_14n I1_I1390_G17_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1390_I142_XG_MP0 (XI1_I1390_I142_XG_p1 I1_I1390_P17_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1390_I142_XG_MP1 (I1_I1390_G17_10 I1_I1390_G13_10n XI1_I1390_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I156_XG_MP2 (VDD I1_I1160_G31_28n I1_I1160_G31_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I156_XG_MP0 (XI1_I1160_I156_XG_p1 I1_I1160_P31_28n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I156_XG_MP1 (I1_I1160_G31_24 I1_I1160_G27_24n XI1_I1160_I156_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I154_XG_MP2 (VDD I1_I1160_G29_26n I1_I1160_G29_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I154_XG_MP0 (XI1_I1160_I154_XG_p1 I1_I1160_P29_26n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I154_XG_MP1 (I1_I1160_G29_22 I1_I1160_G25_22n XI1_I1160_I154_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I69_XG_MP2 (VDD I1_I1160_gn3 I1_I1160_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I69_XG_MP0 (XI1_I1160_I69_XG_p1 I1_I1160_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I69_XG_MP1 (I1_I1160_G3_2 I1_I1160_gn2 XI1_I1160_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I68_XG_MP2 (VDD I1_I1160_gn2 I1_I1160_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1160_I68_XG_MP0 (XI1_I1160_I68_XG_p1 I1_I1160_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1160_I68_XG_MP1 (I1_I1160_G2_1 I1_I1160_gn1 XI1_I1160_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I86_XG_MP2 (VDD I1_I1528_gn20 I1_I1528_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1528_I86_XG_MP0 (XI1_I1528_I86_XG_p1 I1_I1528_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1528_I86_XG_MP1 (I1_I1528_G20_19 I1_I1528_gn19 XI1_I1528_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I85_XG_MP2 (VDD I1_I1528_gn19 I1_I1528_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1528_I85_XG_MP0 (XI1_I1528_I85_XG_p1 I1_I1528_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1528_I85_XG_MP1 (I1_I1528_G19_18 I1_I1528_gn18 XI1_I1528_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I132_XG_MP2 (VDD I1_I1620_G7_4n I1_I1620_G7_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1620_I132_XG_MP0 (XI1_I1620_I132_XG_p1 I1_I1620_P7_4n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1620_I132_XG_MP1 (I1_I1620_G7_0 I1_I1620_G3_0n XI1_I1620_I132_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I134_XG_MP2 (VDD I1_I1620_G9_6n I1_I1620_G9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1620_I134_XG_MP0 (XI1_I1620_I134_XG_p1 I1_I1620_P9_6n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1620_I134_XG_MP1 (I1_I1620_G9_2 I1_I1620_G5_2n XI1_I1620_I134_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1356_MP2 (I1_qu14_b3_4 I1_qu14_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1356_MP2_1 (VDD I1_qu14_b2_1 I1_qu14_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1351_MP2 (I1_qu14_b2_1 I1_qu14_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1351_MP2_1 (VDD I1_qu14_b1_0 I1_qu14_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I499_MP2 (I1_dd29_b3_1 I1_dd29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I499_MP2_1 (VDD I1_dd29_b2_0 I1_dd29_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I486_MP2 (I1_dd28_b3_1 I1_dd28_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I486_MP2_1 (VDD I1_dd28_b2_0 I1_dd28_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I512_MP2 (I1_dd30_b3_1 I1_dd30_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I512_MP2_1 (VDD I1_dd30_b2_0 I1_dd30_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I525_MP2 (I1_dd31_b3_1 I1_dd31_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I525_MP2_1 (VDD I1_dd31_b2_0 I1_dd31_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I383_MP2 (I1_dd20_b3_2 I1_dd20_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I383_MP2_1 (VDD I1_dd20_b2_0 I1_dd20_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I418_MP2 (I1_dd23_b2_0 I1_dd23_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I418_MP2_1 (VDD I1_dd23_b1_0 I1_dd23_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I458_MP2 (I1_dd26_b2_1 I1_dd26_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I458_MP2_1 (VDD I1_dd26_b1_0 I1_dd26_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I445_MP2 (I1_dd25_b2_1 I1_dd25_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I445_MP2_1 (VDD I1_dd25_b1_0 I1_dd25_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I523_MP2 (I1_dd31_b2_1 I1_dd31_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I523_MP2_1 (VDD I1_dd31_b1_0 I1_dd31_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I432_MP2 (I1_dd24_b2_1 I1_dd24_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I432_MP2_1 (VDD I1_dd24_b1_0 I1_dd24_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I37_MP2 (I2_I3_SEL_NOT_b3_3 I2_I3_SEL_NOT_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I37_MP2_1 (VDD I2_I3_SEL_NOT_b2_1 I2_I3_SEL_NOT_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I27_MP2 (I2_I3_SEL_XOR_b3_3 I2_I3_SEL_XOR_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I27_MP2_1 (VDD I2_I3_SEL_XOR_b2_1 I2_I3_SEL_XOR_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I36_MP2 (I2_I3_SEL_NOT_b3_2 I2_I3_SEL_NOT_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I36_MP2_1 (VDD I2_I3_SEL_NOT_b2_0 I2_I3_SEL_NOT_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I26_MP2 (I2_I3_SEL_XOR_b3_2 I2_I3_SEL_XOR_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I26_MP2_1 (VDD I2_I3_SEL_XOR_b2_0 I2_I3_SEL_XOR_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I242_MP2 (I1_dd9_b3_4 I1_dd9_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I242_MP2_1 (VDD I1_dd9_b2_1 I1_dd9_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I229_MP2 (I1_dd8_b3_4 I1_dd8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I229_MP2_1 (VDD I1_dd8_b2_1 I1_dd8_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I655_MP2 (I0_one3_b3_3 I0_one3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I655_MP2_1 (VDD I0_one3_b2_1 I0_one3_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I665_MP2 (I0_two3_b3_3 I0_two3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I665_MP2_1 (VDD I0_two3_b2_1 I0_two3_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I35_MP2 (I2_I3_SEL_NOT_b3_1 I2_I3_SEL_NOT_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I35_MP2_1 (VDD I2_I3_SEL_NOT_b2_0 I2_I3_SEL_NOT_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I25_MP2 (I2_I3_SEL_XOR_b3_1 I2_I3_SEL_XOR_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I25_MP2_1 (VDD I2_I3_SEL_XOR_b2_0 I2_I3_SEL_XOR_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1160_I25_MP1 (I1_I1160_gn25 I1_b13_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I25_MP0 (VDD I1_p12_24 I1_I1160_gn25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1160_I28_MP1 (I1_I1160_gn28 I1_b13_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1160_I28_MP0 (VDD I1_p12_27 I1_I1160_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I310_MP1 (I2_I3_n19_0 I2_AND_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I310_MP0 (VDD I2_I3_SEL_AND_b3_3 I2_I3_n19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I316_MP1 (I2_I3_o19_0 I2_I3_n19_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I316_MP0 (VDD I2_I3_n19_0 I2_I3_o19_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I351_MP1 (I2_I3_n22_5 DIVQ_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I351_MP0 (VDD I2_I3_SEL_DIV_b3_3 I2_I3_n22_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I366_MP1 (I2_I3_o23_2 I2_I3_n23_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I366_MP0 (VDD I2_I3_n23_4 I2_I3_o23_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I382_MP1 (I2_I3_n25_0 I2_AND_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I382_MP0 (VDD I2_I3_SEL_AND_b3_4 I2_I3_n25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I388_MP1 (I2_I3_o25_0 I2_I3_n25_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I388_MP0 (VDD I2_I3_n25_0 I2_I3_o25_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I371_MP1 (I2_I3_n24_1 I2_OR_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I371_MP0 (VDD I2_I3_SEL_OR_b3_4 I2_I3_n24_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I381_MP1 (Y_24 I2_I3_q24_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I381_MP0 (VDD I2_I3_q24_1 Y_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I394_MP1 (I2_I3_n26_0 I2_AND_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I394_MP0 (VDD I2_I3_SEL_AND_b3_4 I2_I3_n26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I400_MP1 (I2_I3_o26_0 I2_I3_n26_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I400_MP0 (VDD I2_I3_n26_0 I2_I3_o26_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I207_MP1 (I2_I3_n10_5 DIVQ_10 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I207_MP0 (VDD I2_I3_SEL_DIV_b3_1 I2_I3_n10_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I192_MP1 (I2_I3_n9_2 I2_XOR_9 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I192_MP0 (VDD I2_I3_SEL_XOR_b3_1 I2_I3_n9_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I145_MP1 (I2_I3_n5_3 I2_NOT_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I145_MP0 (VDD I2_I3_SEL_NOT_b3_0 I2_I3_n5_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I149_MP1 (I2_I3_o5_1 I2_I3_n5_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I149_MP0 (VDD I2_I3_n5_2 I2_I3_o5_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I8_MP1 (I1_I1988_gn8 I1_b31_8 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I8_MP0 (VDD I1_p30_7 I1_I1988_gn8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2016_MP1 (I1_dmn7 I1_p31_32_b3_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2016_MP0 (VDD I1_dd7_b3_5 I1_dmn7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I509_MP1 (I2_I3_hd46 DIVR_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I509_MP0 (VDD I2_I3_SEL_DIV_b3_7 I2_I3_hd46 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I501_MP1 (Y_43 I2_I3_hd43 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I501_MP0 (VDD I2_I3_hm43 Y_43 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I527_MP1 (I2_I3_hd52 DIVR_20 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I527_MP0 (VDD I2_I3_SEL_DIV_b3_8 I2_I3_hd52 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I525_MP1 (Y_51 I2_I3_hd51 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I525_MP0 (VDD I2_I3_hm51 Y_51 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I28_MP1 (I1_I976_gn28 I1_b9_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I28_MP0 (VDD I1_p8_27 I1_I976_gn28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I976_I27_MP1 (I1_I976_gn27 I1_b9_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I976_I27_MP0 (VDD I1_p8_26 I1_I976_gn27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I369_MP1 (Y_23 I2_I3_q23_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I369_MP0 (VDD I2_I3_q23_1 Y_23 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I346_MP1 (I2_I3_n22_0 I2_AND_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I346_MP0 (VDD I2_I3_SEL_AND_b3_4 I2_I3_n22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I352_MP1 (I2_I3_o22_0 I2_I3_n22_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I352_MP0 (VDD I2_I3_n22_0 I2_I3_o22_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I409_MP1 (I2_I3_n27_3 I2_NOT_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I409_MP0 (VDD I2_I3_SEL_NOT_b3_5 I2_I3_n27_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I413_MP1 (I2_I3_o27_1 I2_I3_n27_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I413_MP0 (VDD I2_I3_n27_2 I2_I3_o27_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I253_MP1 (I2_I3_n14_3 I2_NOT_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I253_MP0 (VDD I2_I3_SEL_NOT_b3_2 I2_I3_n14_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I257_MP1 (I2_I3_o14_1 I2_I3_n14_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I257_MP0 (VDD I2_I3_n14_2 I2_I3_o14_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I251_MP1 (I2_I3_n14_1 I2_OR_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I251_MP0 (VDD I2_I3_SEL_OR_b3_2 I2_I3_n14_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I256_MP1 (I2_I3_o14_0 I2_I3_n14_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I256_MP0 (VDD I2_I3_n14_0 I2_I3_o14_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I118_MP1 (I2_I3_n3_0 I2_AND_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I118_MP0 (VDD I2_I3_SEL_AND_b3_0 I2_I3_n3_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I124_MP1 (I2_I3_o3_0 I2_I3_n3_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I124_MP0 (VDD I2_I3_n3_0 I2_I3_o3_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2030_MP1 (I1_dmn14 I1_p31_32_b3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2030_MP0 (VDD I1_dd14_b3_5 I1_dmn14 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2032_MP1 (I1_dmn15 I1_p31_32_b3_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2032_MP0 (VDD I1_dd15_b3_5 I1_dmn15 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I519_MP1 (Y_49 I2_I3_hd49 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I519_MP0 (VDD I2_I3_hm49 Y_49 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I517_MP1 (I2_I3_hm49 MULP_49 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I517_MP0 (VDD I2_I3_SEL_MUL_b3_8 I2_I3_hm49 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I4_I41_MP1 (I2_I4_z1_9 I2_I4_z0_19 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I4_I41_MP0 (VDD I2_I4_z0_18 I2_I4_z1_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I551_MP1 (I2_I3_hd60 DIVR_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I551_MP0 (VDD I2_I3_SEL_DIV_b3_10 I2_I3_hd60 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I548_MP1 (I2_I3_hd59 DIVR_27 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I548_MP0 (VDD I2_I3_SEL_DIV_b3_10 I2_I3_hd59 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1206_I75_XG_MP2 (VDD I1_I1206_gn9 I1_I1206_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1206_I75_XG_MP0 (XI1_I1206_I75_XG_p1 I1_I1206_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1206_I75_XG_MP1 (I1_I1206_G9_8 I1_I1206_gn8 XI1_I1206_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I74_XG_MP2 (VDD I1_I1206_gn8 I1_I1206_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1206_I74_XG_MP0 (XI1_I1206_I74_XG_p1 I1_I1206_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1206_I74_XG_MP1 (I1_I1206_G8_7 I1_I1206_gn7 XI1_I1206_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I74_XG_MP2 (VDD I1_I884_gn8 I1_I884_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I884_I74_XG_MP0 (XI1_I884_I74_XG_p1 I1_I884_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I884_I74_XG_MP1 (I1_I884_G8_7 I1_I884_gn7 XI1_I884_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I73_XG_MP2 (VDD I1_I884_gn7 I1_I884_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I884_I73_XG_MP0 (XI1_I884_I73_XG_p1 I1_I884_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I884_I73_XG_MP1 (I1_I884_G7_6 I1_I884_gn6 XI1_I884_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I94_XG_MP2 (VDD I1_I930_gn28 I1_I930_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I930_I94_XG_MP0 (XI1_I930_I94_XG_p1 I1_I930_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I930_I94_XG_MP1 (I1_I930_G28_27 I1_I930_gn27 XI1_I930_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I93_XG_MP2 (VDD I1_I930_gn27 I1_I930_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I930_I93_XG_MP0 (XI1_I930_I93_XG_p1 I1_I930_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I930_I93_XG_MP1 (I1_I930_G27_26 I1_I930_gn26 XI1_I930_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I92_XG_MP2 (VDD I1_I930_gn26 I1_I930_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I930_I92_XG_MP0 (XI1_I930_I92_XG_p1 I1_I930_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I930_I92_XG_MP1 (I1_I930_G26_25 I1_I930_gn25 XI1_I930_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I930_I91_XG_MP2 (VDD I1_I930_gn25 I1_I930_G25_24 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I930_I91_XG_MP0 (XI1_I930_I91_XG_p1 I1_I930_pn25 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I930_I91_XG_MP1 (I1_I930_G25_24 I1_I930_gn24 XI1_I930_I91_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I149_XG_MP2 (VDD I1_I1390_G24_21n I1_I1390_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1390_I149_XG_MP0 (XI1_I1390_I149_XG_p1 I1_I1390_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1390_I149_XG_MP1 (I1_I1390_G24_17 I1_I1390_G20_17n XI1_I1390_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I145_XG_MP2 (VDD I1_I1390_G20_17n I1_I1390_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1390_I145_XG_MP0 (XI1_I1390_I145_XG_p1 I1_I1390_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1390_I145_XG_MP1 (I1_I1390_G20_13 I1_I1390_G16_13n XI1_I1390_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I74_XG_MP2 (VDD I1_I1436_gn8 I1_I1436_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1436_I74_XG_MP0 (XI1_I1436_I74_XG_p1 I1_I1436_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1436_I74_XG_MP1 (I1_I1436_G8_7 I1_I1436_gn7 XI1_I1436_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1436_I73_XG_MP2 (VDD I1_I1436_gn7 I1_I1436_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1436_I73_XG_MP0 (XI1_I1436_I73_XG_p1 I1_I1436_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1436_I73_XG_MP1 (I1_I1436_G7_6 I1_I1436_gn6 XI1_I1436_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I148_XG_MP2 (VDD I1_I976_G23_20n I1_I976_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I976_I148_XG_MP0 (XI1_I976_I148_XG_p1 I1_I976_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I976_I148_XG_MP1 (I1_I976_G23_16 I1_I976_G19_16n XI1_I976_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I976_I200_XG_MP2 (VDD I1_I976_G29_14n I1_I976_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I976_I200_XG_MP0 (XI1_I976_I200_XG_p1 I1_I976_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I976_I200_XG_MP1 (I1_I976_G29_0 I1_I976_G13_0n XI1_I976_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I69_XG_MP2 (VDD I1_I1482_gn3 I1_I1482_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1482_I69_XG_MP0 (XI1_I1482_I69_XG_p1 I1_I1482_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1482_I69_XG_MP1 (I1_I1482_G3_2 I1_I1482_gn2 XI1_I1482_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1482_I68_XG_MP2 (VDD I1_I1482_gn2 I1_I1482_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1482_I68_XG_MP0 (XI1_I1482_I68_XG_p1 I1_I1482_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1482_I68_XG_MP1 (I1_I1482_G2_1 I1_I1482_gn1 XI1_I1482_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I128_XG_MP2 (VDD I1_I562_G4_1n I1_I562_G4_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I562_I128_XG_MP0 (XI1_I562_I128_XG_p1 I1_I562_P4_1n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I562_I128_XG_MP1 (I1_I562_G4_0 I1_I562_G0_0n XI1_I562_I128_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I131_XG_MP2 (VDD I1_I562_G6_3n I1_I562_G6_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I562_I131_XG_MP0 (XI1_I562_I131_XG_p1 I1_I562_P6_3n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I562_I131_XG_MP1 (I1_I562_G6_0 I1_I562_G2_0n XI1_I562_I131_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I198_XG_MP2 (VDD I1_I1528_G27_12n I1_I1528_G27_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1528_I198_XG_MP0 (XI1_I1528_I198_XG_p1 I1_I1528_P27_12n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1528_I198_XG_MP1 (I1_I1528_G27_0 I1_I1528_G11_0n XI1_I1528_I198_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1528_I200_XG_MP2 (VDD I1_I1528_G29_14n I1_I1528_G29_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1528_I200_XG_MP0 (XI1_I1528_I200_XG_p1 I1_I1528_P29_14n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1528_I200_XG_MP1 (I1_I1528_G29_0 I1_I1528_G13_0n XI1_I1528_I200_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I149_XG_MP2 (VDD I1_I1712_G24_21n I1_I1712_G24_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1712_I149_XG_MP0 (XI1_I1712_I149_XG_p1 I1_I1712_P24_21n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1712_I149_XG_MP1 (I1_I1712_G24_17 I1_I1712_G20_17n XI1_I1712_I149_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1712_I145_XG_MP2 (VDD I1_I1712_G20_17n I1_I1712_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1712_I145_XG_MP0 (XI1_I1712_I145_XG_p1 I1_I1712_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1712_I145_XG_MP1 (I1_I1712_G20_13 I1_I1712_G16_13n XI1_I1712_I145_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I77_XG_MP2 (VDD I1_I1620_gn11 I1_I1620_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1620_I77_XG_MP0 (XI1_I1620_I77_XG_p1 I1_I1620_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1620_I77_XG_MP1 (I1_I1620_G11_10 I1_I1620_gn10 XI1_I1620_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1620_I76_XG_MP2 (VDD I1_I1620_gn10 I1_I1620_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1620_I76_XG_MP0 (XI1_I1620_I76_XG_p1 I1_I1620_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1620_I76_XG_MP1 (I1_I1620_G10_9 I1_I1620_gn9 XI1_I1620_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I94_XG_MP2 (VDD I1_I1666_gn28 I1_I1666_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1666_I94_XG_MP0 (XI1_I1666_I94_XG_p1 I1_I1666_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1666_I94_XG_MP1 (I1_I1666_G28_27 I1_I1666_gn27 XI1_I1666_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I93_XG_MP2 (VDD I1_I1666_gn27 I1_I1666_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1666_I93_XG_MP0 (XI1_I1666_I93_XG_p1 I1_I1666_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1666_I93_XG_MP1 (I1_I1666_G27_26 I1_I1666_gn26 XI1_I1666_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I69_XG_MP2 (VDD I1_I1804_gn3 I1_I1804_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1804_I69_XG_MP0 (XI1_I1804_I69_XG_p1 I1_I1804_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1804_I69_XG_MP1 (I1_I1804_G3_2 I1_I1804_gn2 XI1_I1804_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1804_I68_XG_MP2 (VDD I1_I1804_gn2 I1_I1804_G2_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1804_I68_XG_MP0 (XI1_I1804_I68_XG_p1 I1_I1804_pn2 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1804_I68_XG_MP1 (I1_I1804_G2_1 I1_I1804_gn1 XI1_I1804_I68_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I74_XG_MP2 (VDD I1_I1850_gn8 I1_I1850_G8_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1850_I74_XG_MP0 (XI1_I1850_I74_XG_p1 I1_I1850_pn8 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1850_I74_XG_MP1 (I1_I1850_G8_7 I1_I1850_gn7 XI1_I1850_I74_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1850_I73_XG_MP2 (VDD I1_I1850_gn7 I1_I1850_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1850_I73_XG_MP0 (XI1_I1850_I73_XG_p1 I1_I1850_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1850_I73_XG_MP1 (I1_I1850_G7_6 I1_I1850_gn6 XI1_I1850_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I301_MP1 (I2_I3_n18_3 I2_NOT_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I301_MP0 (VDD I2_I3_SEL_NOT_b3_3 I2_I3_n18_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I2_I108_MP1 (I2_I2_nand18 B_18 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I2_I108_MP0 (VDD A_18 I2_I2_nand18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I335_MP1 (I2_I3_n21_1 I2_OR_21 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I335_MP0 (VDD I2_I3_SEL_OR_b3_3 I2_I3_n21_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I345_MP1 (Y_21 I2_I3_q21_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I345_MP0 (VDD I2_I3_q21_1 Y_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I349_MP1 (I2_I3_n22_3 I2_NOT_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I349_MP0 (VDD I2_I3_SEL_NOT_b3_4 I2_I3_n22_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I353_MP1 (I2_I3_o22_1 I2_I3_n22_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I353_MP0 (VDD I2_I3_n22_2 I2_I3_o22_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I279_MP1 (I2_I3_n16_5 DIVQ_16 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I279_MP0 (VDD I2_I3_SEL_DIV_b3_2 I2_I3_n16_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I291_MP1 (I2_I3_n17_5 DIVQ_17 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I291_MP0 (VDD I2_I3_SEL_DIV_b3_2 I2_I3_n17_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I454_MP1 (I2_I3_n31_0 I2_AND_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I454_MP0 (VDD I2_I3_SEL_AND_b3_5 I2_I3_n31_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I460_MP1 (I2_I3_o31_0 I2_I3_n31_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I460_MP0 (VDD I2_I3_n31_0 I2_I3_o31_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I4_MP1 (I2_I1_I42_gn4 I2_I1_bx4 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I4_MP0 (VDD A_4 I2_I1_I42_gn4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I1_I42_I3_MP1 (I2_I1_I42_gn3 I2_I1_bx3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I1_I42_I3_MP0 (VDD A_3 I2_I1_I42_gn3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I120_MP1 (I2_I3_n3_2 I2_XOR_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I120_MP0 (VDD I2_I3_SEL_XOR_b3_0 I2_I3_n3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I125_MP1 (I2_I3_o3_1 I2_I3_n3_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I125_MP0 (VDD I2_I3_n3_2 I2_I3_o3_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2042_MP1 (I1_dmn20 I1_p31_32_b3_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2042_MP0 (VDD I1_dd20_b3_5 I1_dmn20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I22_MP1 (I1_I1988_gn22 I1_b31_22 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I22_MP0 (VDD I1_p30_21 I1_I1988_gn22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I125_XP_MP1 (I1_I1942_P29_26n I1_I1942_P27_26 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I125_XP_MP0 (VDD I1_I1942_P29_28 I1_I1942_P29_26n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1942_I127_XP_MP1 (I1_I1942_P31_28n I1_I1942_P29_28 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1942_I127_XP_MP0 (VDD I1_I1942_P31_30 I1_I1942_P31_28n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2062_MP1 (I1_dmn30 I1_p31_32_b3_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2062_MP0 (VDD I1_dd30_b3_5 I1_dmn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1988_I30_MP1 (I1_I1988_gn30 I1_b31_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1988_I30_MP0 (VDD I1_p30_29 I1_I1988_gn30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I557_MP1 (I2_I3_hd62 DIVR_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I557_MP0 (VDD I2_I3_SEL_DIV_b3_10 I2_I3_hd62 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I560_MP1 (I2_I3_hd63 DIVR_31 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I560_MP0 (VDD I2_I3_SEL_DIV_b3_10 I2_I3_hd63 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I104_XP_MP1 (I1_I838_P8_5n I1_I838_P6_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I104_XP_MP0 (VDD I1_I838_P8_7 I1_I838_P8_5n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I838_I102_XP_MP1 (I1_I838_P6_3n I1_I838_P4_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I838_I102_XP_MP0 (VDD I1_I838_P6_5 I1_I838_P6_3n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I113_XP_MP1 (I1_I1436_P17_14n I1_I1436_P15_14 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I113_XP_MP0 (VDD I1_I1436_P17_16 I1_I1436_P17_14n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1436_I111_XP_MP1 (I1_I1436_P15_12n I1_I1436_P13_12 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I1436_I111_XP_MP0 (VDD I1_I1436_P15_14 I1_I1436_P15_12n VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I389_MP1 (I2_I3_o25_1 I2_I3_n25_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I389_MP0 (VDD I2_I3_n25_2 I2_I3_o25_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I384_MP1 (I2_I3_n25_2 I2_XOR_25 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I384_MP0 (VDD I2_I3_SEL_XOR_b3_4 I2_I3_n25_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I435_MP1 (I2_I3_n29_5 DIVQ_29 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I435_MP0 (VDD I2_I3_SEL_DIV_b3_4 I2_I3_n29_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I2294_MP1 (I1_vn I1_sqn VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI1_I2294_MP0 (VDD DIVQ_31 I1_vn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I377_MP1 (I2_I3_o24_1 I2_I3_n24_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I377_MP0 (VDD I2_I3_n24_2 I2_I3_o24_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I372_MP1 (I2_I3_n24_2 I2_XOR_24 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I372_MP0 (VDD I2_I3_SEL_XOR_b3_4 I2_I3_n24_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I426_MP1 (I2_I3_o28_2 I2_I3_n28_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I426_MP0 (VDD I2_I3_n28_4 I2_I3_o28_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I4_I68_MP1 (I2_I4_v2 DIVV VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I4_I68_MP0 (VDD I2_SEL_DIV I2_I4_v2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I4_I57_MP1 (I2_I4_z3_1 I2_I4_z2_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I4_I57_MP0 (VDD I2_I4_z2_2 I2_I4_z3_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I449_MP1 (I2_I3_o30_1 I2_I3_n30_3 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I449_MP0 (VDD I2_I3_n30_2 I2_I3_o30_1 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I444_MP1 (I2_I3_n30_2 I2_XOR_30 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I444_MP0 (VDD I2_I3_SEL_XOR_b3_5 I2_I3_n30_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I4_I38_MP1 (I2_I4_z1_6 I2_I4_z0_13 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I4_I38_MP0 (VDD I2_I4_z0_12 I2_I4_z1_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I4_I39_MP1 (I2_I4_z1_7 I2_I4_z0_15 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I4_I39_MP0 (VDD I2_I4_z0_14 I2_I4_z1_7 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I0_I4_MP1 (I2_I0_h00 I2_I0_opn2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I0_I4_MP0 (VDD I2_I0_opn3 I2_I0_h00 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I0_I5_MP1 (I2_I0_h01 OP_2 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I0_I5_MP0 (VDD I2_I0_opn3 I2_I0_h01 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I102_MP1 (I2_I3_o1_2 I2_I3_n1_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I102_MP0 (VDD I2_I3_n1_4 I2_I3_o1_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I138_MP1 (I2_I3_o4_2 I2_I3_n4_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I138_MP0 (VDD I2_I3_n4_4 I2_I3_o4_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I98_MP1 (I2_I3_n1_4 MULP_1 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I98_MP0 (VDD I2_I3_SEL_MUL_b3_0 I2_I3_n1_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I146_MP1 (I2_I3_n5_4 MULP_5 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I146_MP0 (VDD I2_I3_SEL_MUL_b3_0 I2_I3_n5_4 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I490_MP1 (I2_I3_hm40 MULP_40 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I490_MP0 (VDD I2_I3_SEL_MUL_b3_6 I2_I3_hm40 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I478_MP1 (I2_I3_hm36 MULP_36 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I478_MP0 (VDD I2_I3_SEL_MUL_b3_6 I2_I3_hm36 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I511_MP1 (I2_I3_hm47 MULP_47 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I511_MP0 (VDD I2_I3_SEL_MUL_b3_8 I2_I3_hm47 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I514_MP1 (I2_I3_hm48 MULP_48 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I514_MP0 (VDD I2_I3_SEL_MUL_b3_8 I2_I3_hm48 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I541_MP1 (I2_I3_hm57 MULP_57 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I541_MP0 (VDD I2_I3_SEL_MUL_b3_9 I2_I3_hm57 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I538_MP1 (I2_I3_hm56 MULP_56 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I538_MP0 (VDD I2_I3_SEL_MUL_b3_9 I2_I3_hm56 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I532_MP1 (I2_I3_hm54 MULP_54 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I532_MP0 (VDD I2_I3_SEL_MUL_b3_9 I2_I3_hm54 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI2_I3_I544_MP1 (I2_I3_hm58 MULP_58 VDD VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0528p as=0.0816p pd=0.68u ps=1.16u
    I_MXI2_I3_I544_MP0 (VDD I2_I3_SEL_MUL_b3_9 I2_I3_hm58 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0528p pd=1.16u ps=0.68u
    I_MXI1_I1212_MP2 (I1_qu17_b2_0 I1_qu17_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1212_MP2_1 (VDD I1_qu17_b1_0 I1_qu17_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1211_MP2 (I1_qu17_b1_0 I1_qu17_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1211_MP2_1 (VDD I1_qu17_b0 I1_qu17_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I896_MP2 (I1_qu24_b3_4 I1_qu24_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I896_MP2_1 (VDD I1_qu24_b2_1 I1_qu24_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I891_MP2 (I1_qu24_b2_1 I1_qu24_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I891_MP2_1 (VDD I1_qu24_b1_0 I1_qu24_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I487_MP2 (I1_dd28_b3_2 I1_dd28_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I487_MP2_1 (VDD I1_dd28_b2_0 I1_dd28_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I470_MP2 (I1_dd27_b2_0 I1_dd27_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I470_MP2_1 (VDD I1_dd27_b1_0 I1_dd27_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I483_MP2 (I1_dd28_b2_0 I1_dd28_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I483_MP2_1 (VDD I1_dd28_b1_0 I1_dd28_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I150_MP2 (I1_dd2_b3_3 I1_dd2_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I150_MP2_1 (VDD I1_dd2_b2_1 I1_dd2_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I189_MP2 (I1_dd5_b3_3 I1_dd5_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I189_MP2_1 (VDD I1_dd5_b2_1 I1_dd5_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I159_MP2 (I1_dd3_b2_1 I1_dd3_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I159_MP2_1 (VDD I1_dd3_b1_0 I1_dd3_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I261_MP2 (I1_dd11_b1_0 I1_dd11_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I261_MP2_1 (VDD I1_dd11_b0 I1_dd11_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I222_MP2 (I1_dd8_b1_0 I1_dd8_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I222_MP2_1 (VDD I1_dd8_b0 I1_dd8_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I196_MP2 (I1_dd6_b1_0 I1_dd6_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I196_MP2_1 (VDD I1_dd6_b0 I1_dd6_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I170_MP2 (I1_dd4_b1_0 I1_dd4_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I170_MP2_1 (VDD I1_dd4_b0 I1_dd4_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I236_MP2 (I0_A_22_b3_2 I0_A_22_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I236_MP2_1 (VDD I0_A_22_b2_0 I0_A_22_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I265_MP2 (I0_A_25_b3_1 I0_A_25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I265_MP2_1 (VDD I0_A_25_b2_0 I0_A_25_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I498_MP2 (I0_two0_b3_1 I0_two0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I498_MP2_1 (VDD I0_two0_b2_0 I0_two0_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I488_MP2 (I0_one0_b3_1 I0_one0_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I488_MP2_1 (VDD I0_one0_b2_0 I0_one0_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I471_MP2 (I0_B_29_b3_5 I0_B_29_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I471_MP2_1 (VDD I0_B_29_b2_1 I0_B_29_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1156_MP2 (I0_two12_b2_1 I0_two12_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1156_MP2_1 (VDD I0_two12_b1_0 I0_two12_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I451_MP2 (I0_B_25_b3_5 I0_B_25_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I451_MP2_1 (VDD I0_B_25_b2_1 I0_B_25_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I481_MP2 (I0_B_31_b3_5 I0_B_31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I481_MP2_1 (VDD I0_B_31_b2_1 I0_B_31_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I460_MP2 (I0_B_27_b3_4 I0_B_27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I460_MP2_1 (VDD I0_B_27_b2_1 I0_B_27_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1317_MP2 (I0_one15_b3_5 I0_one15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1317_MP2_1 (VDD I0_one15_b2_1 I0_one15_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1327_MP2 (I0_two15_b3_5 I0_two15_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1327_MP2_1 (VDD I0_two15_b2_1 I0_two15_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I805_MP2 (I1_qu26_b3_5 I1_qu26_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I805_MP2_1 (VDD I1_qu26_b2_1 I1_qu26_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I799_MP2 (I1_qu26_b2_1 I1_qu26_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I799_MP2_1 (VDD I1_qu26_b1_0 I1_qu26_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I444_MP2 (I1_dd25_b2_0 I1_dd25_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I444_MP2_1 (VDD I1_dd25_b1_0 I1_dd25_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I457_MP2 (I1_dd26_b2_0 I1_dd26_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I457_MP2_1 (VDD I1_dd26_b1_0 I1_dd26_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I409_MP2 (I1_dd22_b3_2 I1_dd22_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I409_MP2_1 (VDD I1_dd22_b2_0 I1_dd22_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I422_MP2 (I1_dd23_b3_2 I1_dd23_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I422_MP2_1 (VDD I1_dd23_b2_0 I1_dd23_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I370_MP2 (I1_dd19_b3_2 I1_dd19_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I370_MP2_1 (VDD I1_dd19_b2_0 I1_dd19_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I357_MP2 (I1_dd18_b3_2 I1_dd18_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I357_MP2_1 (VDD I1_dd18_b2_0 I1_dd18_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I318_MP2 (I1_dd15_b3_2 I1_dd15_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I318_MP2_1 (VDD I1_dd15_b2_0 I1_dd15_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I331_MP2 (I1_dd16_b3_2 I1_dd16_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I331_MP2_1 (VDD I1_dd16_b2_0 I1_dd16_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I380_MP2 (I1_dd20_b2_1 I1_dd20_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I380_MP2_1 (VDD I1_dd20_b1_0 I1_dd20_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I289_MP2 (I1_dd13_b2_1 I1_dd13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I289_MP2_1 (VDD I1_dd13_b1_0 I1_dd13_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I354_MP2 (I1_dd18_b2_1 I1_dd18_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I354_MP2_1 (VDD I1_dd18_b1_0 I1_dd18_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I254_MP2 (I1_dd10_b3_3 I1_dd10_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I254_MP2_1 (VDD I1_dd10_b2_1 I1_dd10_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I16_MP2 (I2_I3_SEL_OR_b3_2 I2_I3_SEL_OR_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I16_MP2_1 (VDD I2_I3_SEL_OR_b2_0 I2_I3_SEL_OR_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I6_MP2 (I2_I3_SEL_AND_b3_2 I2_I3_SEL_AND_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I6_MP2_1 (VDD I2_I3_SEL_AND_b2_0 I2_I3_SEL_AND_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I202_MP2 (I0_A_19_b2_0 I0_A_19_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I202_MP2_1 (VDD I0_A_19_b1_0 I0_A_19_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I721_MP2 (I0_two4_b3_4 I0_two4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I721_MP2_1 (VDD I0_two4_b2_1 I0_two4_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I132_MP2 (I0_A_12_b2_0 I0_A_12_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I132_MP2_1 (VDD I0_A_12_b1_0 I0_A_12_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I135_MP2 (I0_A_12_b3_1 I0_A_12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I135_MP2_1 (VDD I0_A_12_b2_0 I0_A_12_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I5_MP2 (I0_B_1_b3_1 I0_B_1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I5_MP2_1 (VDD I0_B_1_b2_0 I0_B_1_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I542_MP2 (I0_one1_b3_0 I0_one1_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I542_MP2_1 (VDD I0_one1_b2_0 I0_one1_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I884_MP2 (I0_two7_b3_2 I0_two7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I884_MP2_1 (VDD I0_two7_b2_0 I0_two7_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I880_MP2 (I0_two7_b2_0 I0_two7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I880_MP2_1 (VDD I0_two7_b1_0 I0_two7_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I411_MP2 (I1_dd22_b3_4 I1_dd22_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I411_MP2_1 (VDD I1_dd22_b2_1 I1_dd22_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I528_MP2 (I1_dd31_b3_4 I1_dd31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I528_MP2_1 (VDD I1_dd31_b2_1 I1_dd31_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I177_MP2 (I0_A_16_b3_3 I0_A_16_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I177_MP2_1 (VDD I0_A_16_b2_1 I0_A_16_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I428_MP2 (I0_B_21_b3_2 I0_B_21_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I428_MP2_1 (VDD I0_B_21_b2_0 I0_B_21_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I424_MP2 (I0_B_21_b2_0 I0_B_21_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I424_MP2_1 (VDD I0_B_21_b1_0 I0_B_21_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1105_MP2 (I0_two11_b3_3 I0_two11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1105_MP2_1 (VDD I0_two11_b2_1 I0_two11_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1095_MP2 (I0_one11_b3_3 I0_one11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1095_MP2_1 (VDD I0_one11_b2_1 I0_one11_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I146_XP_MP0 (XI1_I746_I146_XP_p1 I1_I746_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I146_XP_MP1 (I1_I746_P21_14 I1_I746_P17_14n XI1_I746_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I150_XP_MP0 (XI1_I746_I150_XP_p1 I1_I746_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I150_XP_MP1 (I1_I746_P25_18 I1_I746_P21_18n XI1_I746_I150_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I143_XP_MP0 (XI1_I700_I143_XP_p1 I1_I700_P18_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I143_XP_MP1 (I1_I700_P18_11 I1_I700_P14_11n XI1_I700_I143_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I145_XP_MP0 (XI1_I700_I145_XP_p1 I1_I700_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I700_I145_XP_MP1 (I1_I700_P20_13 I1_I700_P16_13n XI1_I700_I145_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I85_XP_MP0 (XI2_I1_I42_I85_XP_p1 I2_I1_I42_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I85_XP_MP1 (I2_I1_I42_P19_18 I2_I1_I42_pn18 XI2_I1_I42_I85_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I86_XP_MP0 (XI2_I1_I42_I86_XP_p1 I2_I1_I42_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I86_XP_MP1 (I2_I1_I42_P20_19 I2_I1_I42_pn19 XI2_I1_I42_I86_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I87_XP_MP0 (XI2_I1_I42_I87_XP_p1 I2_I1_I42_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I87_XP_MP1 (I2_I1_I42_P21_20 I2_I1_I42_pn20 XI2_I1_I42_I87_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I88_XP_MP0 (XI2_I1_I42_I88_XP_p1 I2_I1_I42_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I1_I42_I88_XP_MP1 (I2_I1_I42_P22_21 I2_I1_I42_pn21 XI2_I1_I42_I88_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I4_I12_MP0 (XI2_I4_I12_p1 Y_24 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I4_I12_MP1 (I2_I4_z0_12 Y_25 XI2_I4_I12_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I4_I14_MP0 (XI2_I4_I14_p1 Y_28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I4_I14_MP1 (I2_I4_z0_14 Y_29 XI2_I4_I14_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I144_XP_MP0 (XI1_I1666_I144_XP_p1 I1_I1666_P19_16n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I144_XP_MP1 (I1_I1666_P19_12 I1_I1666_P15_12n XI1_I1666_I144_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1666_I146_XP_MP0 (XI1_I1666_I146_XP_p1 I1_I1666_P21_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1666_I146_XP_MP1 (I1_I1666_P21_14 I1_I1666_P17_14n XI1_I1666_I146_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I290_XP_MP0 (XI0_I1660_I290_XP_p1 I0_I1660_P37_34n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I290_XP_MP1 (I0_I1660_P37_30 I0_I1660_P33_30n XI0_I1660_I290_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I292_XP_MP0 (XI0_I1660_I292_XP_p1 I0_I1660_P39_36n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I292_XP_MP1 (I0_I1660_P39_32 I0_I1660_P35_32n XI0_I1660_I292_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I283_XP_MP0 (XI0_I1660_I283_XP_p1 I0_I1660_P30_27n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I283_XP_MP1 (I0_I1660_P30_23 I0_I1660_P26_23n XI0_I1660_I283_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I407_XP_MP0 (XI0_I1660_I407_XP_p1 I0_I1660_P44_29n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1660_I407_XP_MP1 (I0_I1660_P44_13 I0_I1660_P28_13n XI0_I1660_I407_XP_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I96_XG_MP2 (VDD I1_I1298_gn30 I1_I1298_G30_29 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1298_I96_XG_MP0 (XI1_I1298_I96_XG_p1 I1_I1298_pn30 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1298_I96_XG_MP1 (I1_I1298_G30_29 I1_I1298_gn29 XI1_I1298_I96_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I97_XG_MP2 (VDD I1_I1298_gn31 I1_I1298_G31_30 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1298_I97_XG_MP0 (XI1_I1298_I97_XG_p1 I1_I1298_pn31 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1298_I97_XG_MP1 (I1_I1298_G31_30 I1_I1298_gn30 XI1_I1298_I97_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I150_XG_MP2 (VDD I1_I792_G25_22n I1_I792_G25_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I792_I150_XG_MP0 (XI1_I792_I150_XG_p1 I1_I792_P25_22n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I792_I150_XG_MP1 (I1_I792_G25_18 I1_I792_G21_18n XI1_I792_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I148_XG_MP2 (VDD I1_I792_G23_20n I1_I792_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I792_I148_XG_MP0 (XI1_I792_I148_XG_p1 I1_I792_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I792_I148_XG_MP1 (I1_I792_G23_16 I1_I792_G19_16n XI1_I792_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I76_XG_MP2 (VDD I1_I792_gn10 I1_I792_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I792_I76_XG_MP0 (XI1_I792_I76_XG_p1 I1_I792_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I792_I76_XG_MP1 (I1_I792_G10_9 I1_I792_gn9 XI1_I792_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I77_XG_MP2 (VDD I1_I792_gn11 I1_I792_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I792_I77_XG_MP0 (XI1_I792_I77_XG_p1 I1_I792_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I792_I77_XG_MP1 (I1_I792_G11_10 I1_I792_gn10 XI1_I792_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I72_XG_MP2 (VDD I1_I792_gn6 I1_I792_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I792_I72_XG_MP0 (XI1_I792_I72_XG_p1 I1_I792_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I792_I72_XG_MP1 (I1_I792_G6_5 I1_I792_gn5 XI1_I792_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I73_XG_MP2 (VDD I1_I792_gn7 I1_I792_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I792_I73_XG_MP0 (XI1_I792_I73_XG_p1 I1_I792_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I792_I73_XG_MP1 (I1_I792_G7_6 I1_I792_gn6 XI1_I792_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I86_XG_MP2 (VDD I1_I746_gn20 I1_I746_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I746_I86_XG_MP0 (XI1_I746_I86_XG_p1 I1_I746_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I746_I86_XG_MP1 (I1_I746_G20_19 I1_I746_gn19 XI1_I746_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I87_XG_MP2 (VDD I1_I746_gn21 I1_I746_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I746_I87_XG_MP0 (XI1_I746_I87_XG_p1 I1_I746_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I746_I87_XG_MP1 (I1_I746_G21_20 I1_I746_gn20 XI1_I746_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I148_XG_MP2 (VDD I1_I700_G23_20n I1_I700_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I700_I148_XG_MP0 (XI1_I700_I148_XG_p1 I1_I700_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I700_I148_XG_MP1 (I1_I700_G23_16 I1_I700_G19_16n XI1_I700_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I152_XG_MP2 (VDD I1_I700_G27_24n I1_I700_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I700_I152_XG_MP0 (XI1_I700_I152_XG_p1 I1_I700_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I700_I152_XG_MP1 (I1_I700_G27_20 I1_I700_G23_20n XI1_I700_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I199_XG_MP2 (VDD I1_I700_G28_13n I1_I700_G28_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I700_I199_XG_MP0 (XI1_I700_I199_XG_p1 I1_I700_P28_13n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I700_I199_XG_MP1 (I1_I700_G28_0 I1_I700_G12_0n XI1_I700_I199_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I201_XG_MP2 (VDD I1_I700_G30_15n I1_c3_m VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I700_I201_XG_MP0 (XI1_I700_I201_XG_p1 I1_I700_P30_15n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I700_I201_XG_MP1 (I1_c3_m I1_I700_G14_0n XI1_I700_I201_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I75_XG_MP2 (VDD I1_I700_gn9 I1_I700_G9_8 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I700_I75_XG_MP0 (XI1_I700_I75_XG_p1 I1_I700_pn9 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I700_I75_XG_MP1 (I1_I700_G9_8 I1_I700_gn8 XI1_I700_I75_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I76_XG_MP2 (VDD I1_I700_gn10 I1_I700_G10_9 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I700_I76_XG_MP0 (XI1_I700_I76_XG_p1 I1_I700_pn10 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I700_I76_XG_MP1 (I1_I700_G10_9 I1_I700_gn9 XI1_I700_I76_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I77_XG_MP2 (VDD I1_I700_gn11 I1_I700_G11_10 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I700_I77_XG_MP0 (XI1_I700_I77_XG_p1 I1_I700_pn11 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I700_I77_XG_MP1 (I1_I700_G11_10 I1_I700_gn10 XI1_I700_I77_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I87_XG_MP2 (VDD I1_I700_gn21 I1_I700_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I700_I87_XG_MP0 (XI1_I700_I87_XG_p1 I1_I700_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I700_I87_XG_MP1 (I1_I700_G21_20 I1_I700_gn20 XI1_I700_I87_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I88_XG_MP2 (VDD I1_I700_gn22 I1_I700_G22_21 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I700_I88_XG_MP0 (XI1_I700_I88_XG_p1 I1_I700_pn22 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I700_I88_XG_MP1 (I1_I700_G22_21 I1_I700_gn21 XI1_I700_I88_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I700_I89_XG_MP2 (VDD I1_I700_gn23 I1_I700_G23_22 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I700_I89_XG_MP0 (XI1_I700_I89_XG_p1 I1_I700_pn23 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I700_I89_XG_MP1 (I1_I700_G23_22 I1_I700_gn22 XI1_I700_I89_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I78_XG_MP2 (VDD I1_I608_gn12 I1_I608_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I608_I78_XG_MP0 (XI1_I608_I78_XG_p1 I1_I608_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I608_I78_XG_MP1 (I1_I608_G12_11 I1_I608_gn11 XI1_I608_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I79_XG_MP2 (VDD I1_I608_gn13 I1_I608_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I608_I79_XG_MP0 (XI1_I608_I79_XG_p1 I1_I608_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I608_I79_XG_MP1 (I1_I608_G13_12 I1_I608_gn12 XI1_I608_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I83_XG_MP2 (VDD I1_I562_gn17 I1_I562_G17_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I562_I83_XG_MP0 (XI1_I562_I83_XG_p1 I1_I562_pn17 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I562_I83_XG_MP1 (I1_I562_G17_16 I1_I562_gn16 XI1_I562_I83_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I562_I84_XG_MP2 (VDD I1_I562_gn18 I1_I562_G18_17 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I562_I84_XG_MP0 (XI1_I562_I84_XG_p1 I1_I562_pn18 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I562_I84_XG_MP1 (I1_I562_G18_17 I1_I562_gn17 XI1_I562_I84_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I142_XG_MP2 (VDD I0_I1660_gn12 I0_I1660_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI0_I1660_I142_XG_MP0 (XI0_I1660_I142_XG_p1 I0_I1660_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI0_I1660_I142_XG_MP1 (I0_I1660_G12_11 I0_I1660_gn11 XI0_I1660_I142_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I143_XG_MP2 (VDD I0_I1660_gn13 I0_I1660_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI0_I1660_I143_XG_MP0 (XI0_I1660_I143_XG_p1 I0_I1660_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI0_I1660_I143_XG_MP1 (I0_I1660_G13_12 I0_I1660_gn12 XI0_I1660_I143_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I144_XG_MP2 (VDD I0_I1660_gn14 I0_I1660_G14_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI0_I1660_I144_XG_MP0 (XI0_I1660_I144_XG_p1 I0_I1660_pn14 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI0_I1660_I144_XG_MP1 (I0_I1660_G14_13 I0_I1660_gn13 XI0_I1660_I144_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I396_XG_MP2 (VDD I0_I1660_G33_18n I0_I1660_G33_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI0_I1660_I396_XG_MP0 (XI0_I1660_I396_XG_p1 I0_I1660_P33_18n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI0_I1660_I396_XG_MP1 (I0_I1660_G33_2 I0_I1660_G17_2n XI0_I1660_I396_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I273_XG_MP2 (VDD I0_I1660_G20_17n I0_I1660_G20_13 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI0_I1660_I273_XG_MP0 (XI0_I1660_I273_XG_p1 I0_I1660_P20_17n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI0_I1660_I273_XG_MP1 (I0_I1660_G20_13 I0_I1660_G16_13n XI0_I1660_I273_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1265_MP2 (I1_qu16_b3_5 I1_qu16_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1265_MP2_1 (VDD I1_qu16_b2_1 I1_qu16_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1264_MP2 (I1_qu16_b3_4 I1_qu16_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1264_MP2_1 (VDD I1_qu16_b2_1 I1_qu16_b3_4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1259_MP2 (I1_qu16_b2_1 I1_qu16_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1259_MP2_1 (VDD I1_qu16_b1_0 I1_qu16_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1258_MP2 (I1_qu16_b2_0 I1_qu16_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1258_MP2_1 (VDD I1_qu16_b1_0 I1_qu16_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1263_MP2 (I1_qu16_b3_3 I1_qu16_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1263_MP2_1 (VDD I1_qu16_b2_1 I1_qu16_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I711_MP2 (I1_qu28_b3_3 I1_qu28_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I711_MP2_1 (VDD I1_qu28_b2_1 I1_qu28_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I706_MP2 (I1_qu28_b2_0 I1_qu28_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I706_MP2_1 (VDD I1_qu28_b1_0 I1_qu28_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I163_MP2 (I1_dd3_b3_3 I1_dd3_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I163_MP2_1 (VDD I1_dd3_b2_1 I1_dd3_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I211_MP2 (I1_dd7_b2_1 I1_dd7_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I211_MP2_1 (VDD I1_dd7_b1_0 I1_dd7_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I176_MP2 (I1_dd4_b3_3 I1_dd4_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I176_MP2_1 (VDD I1_dd4_b2_1 I1_dd4_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I386_MP2 (I0_B_13_b3_0 I0_B_13_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I386_MP2_1 (VDD I0_B_13_b2_0 I0_B_13_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I770_MP2 (I0_two5_b2_0 I0_two5_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I770_MP2_1 (VDD I0_two5_b1_0 I0_two5_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I815_MP2 (I0_one6_b2_0 I0_one6_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I815_MP2_1 (VDD I0_one6_b1_0 I0_one6_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I384_MP2 (I0_B_13_b2_0 I0_B_13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I384_MP2_1 (VDD I0_B_13_b1_0 I0_B_13_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I142_MP2 (I0_A_13_b2_0 I0_A_13_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I142_MP2_1 (VDD I0_A_13_b1_0 I0_A_13_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I85_MP2 (I0_A_7_b3_1 I0_A_7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I85_MP2_1 (VDD I0_A_7_b2_0 I0_A_7_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I708_MP2 (I0_one4_b3_1 I0_one4_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I708_MP2_1 (VDD I0_one4_b2_0 I0_one4_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I407_MP2 (I0_B_17_b3_1 I0_B_17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I407_MP2_1 (VDD I0_B_17_b2_0 I0_B_17_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I406_MP2 (I0_B_17_b3_0 I0_B_17_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I406_MP2_1 (VDD I0_B_17_b2_0 I0_B_17_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I477_MP2 (I1_dd27_b3_5 I1_dd27_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I477_MP2_1 (VDD I1_dd27_b2_1 I1_dd27_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I490_MP2 (I1_dd28_b3_5 I1_dd28_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I490_MP2_1 (VDD I1_dd28_b2_1 I1_dd28_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I230_MP2 (I1_dd8_b3_5 I1_dd8_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I230_MP2_1 (VDD I1_dd8_b2_1 I1_dd8_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I269_MP2 (I1_dd11_b3_5 I1_dd11_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I269_MP2_1 (VDD I1_dd11_b2_1 I1_dd11_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I707_MP2 (I1_qu28_b2_1 I1_qu28_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I707_MP2_1 (VDD I1_qu28_b1_0 I1_qu28_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I705_MP2 (I1_qu28_b1_0 I1_qu28_b0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I705_MP2_1 (VDD I1_qu28_b0 I1_qu28_b1_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I474_MP2 (I1_dd27_b3_2 I1_dd27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I474_MP2_1 (VDD I1_dd27_b2_0 I1_dd27_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I500_MP2 (I1_dd29_b3_2 I1_dd29_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I500_MP2_1 (VDD I1_dd29_b2_0 I1_dd29_b3_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I496_MP2 (I1_dd29_b2_0 I1_dd29_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I496_MP2_1 (VDD I1_dd29_b1_0 I1_dd29_b2_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I473_MP2 (I1_dd27_b3_1 I1_dd27_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I473_MP2_1 (VDD I1_dd27_b2_0 I1_dd27_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I213_MP2 (I1_dd7_b3_1 I1_dd7_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I213_MP2_1 (VDD I1_dd7_b2_0 I1_dd7_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I200_MP2 (I1_dd6_b3_1 I1_dd6_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I200_MP2_1 (VDD I1_dd6_b2_0 I1_dd6_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I341_MP2 (I1_dd17_b2_1 I1_dd17_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I341_MP2_1 (VDD I1_dd17_b1_0 I1_dd17_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I202_MP2 (I1_dd6_b3_3 I1_dd6_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I202_MP2_1 (VDD I1_dd6_b2_1 I1_dd6_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I389_MP2 (I0_B_13_b3_3 I0_B_13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I389_MP2_1 (VDD I0_B_13_b2_1 I0_B_13_b3_3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I391_MP2 (I0_B_13_b3_5 I0_B_13_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I391_MP2_1 (VDD I0_B_13_b2_1 I0_B_13_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I529_MP2 (I1_dd31_b3_5 I1_dd31_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I529_MP2_1 (VDD I1_dd31_b2_1 I1_dd31_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I334_MP2 (I1_dd16_b3_5 I1_dd16_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I334_MP2_1 (VDD I1_dd16_b2_1 I1_dd16_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1158_MP2 (I0_two12_b3_1 I0_two12_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I1158_MP2_1 (VDD I0_two12_b2_0 I0_two12_b3_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I446_MP2 (I0_B_25_b3_0 I0_B_25_b2_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI0_I446_MP2_1 (VDD I0_B_25_b2_0 I0_B_25_b3_0 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I50_MP2 (I2_I3_SEL_MUL_b3_5 I2_I3_SEL_MUL_b2_1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I50_MP2_1 (VDD I2_I3_SEL_MUL_b2_1 I2_I3_SEL_MUL_b3_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I3_I43_MP2 (I2_I3_SEL_MUL_b2_1 I2_I3_SEL_MUL_b1_0 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI2_I3_I43_MP2_1 (VDD I2_I3_SEL_MUL_b1_0 I2_I3_SEL_MUL_b2_1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I67_XG_MP2 (VDD I1_I792_gn1 I1_I792_G1_0 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I792_I67_XG_MP0 (XI1_I792_I67_XG_p1 I1_I792_pn1 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I792_I67_XG_MP1 (I1_I792_G1_0 I1_I792_G0_0n XI1_I792_I67_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I69_XG_MP2 (VDD I1_I792_gn3 I1_I792_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I792_I69_XG_MP0 (XI1_I792_I69_XG_p1 I1_I792_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I792_I69_XG_MP1 (I1_I792_G3_2 I1_I792_gn2 XI1_I792_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I78_XG_MP2 (VDD I1_I746_gn12 I1_I746_G12_11 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I746_I78_XG_MP0 (XI1_I746_I78_XG_p1 I1_I746_pn12 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I746_I78_XG_MP1 (I1_I746_G12_11 I1_I746_gn11 XI1_I746_I78_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I79_XG_MP2 (VDD I1_I746_gn13 I1_I746_G13_12 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I746_I79_XG_MP0 (XI1_I746_I79_XG_p1 I1_I746_pn13 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I746_I79_XG_MP1 (I1_I746_G13_12 I1_I746_gn12 XI1_I746_I79_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I72_XG_MP2 (VDD I1_I746_gn6 I1_I746_G6_5 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I746_I72_XG_MP0 (XI1_I746_I72_XG_p1 I1_I746_pn6 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I746_I72_XG_MP1 (I1_I746_G6_5 I1_I746_gn5 XI1_I746_I72_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I73_XG_MP2 (VDD I1_I746_gn7 I1_I746_G7_6 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I746_I73_XG_MP0 (XI1_I746_I73_XG_p1 I1_I746_pn7 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I746_I73_XG_MP1 (I1_I746_G7_6 I1_I746_gn6 XI1_I746_I73_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I94_XG_MP2 (VDD I1_I654_gn28 I1_I654_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I654_I94_XG_MP0 (XI1_I654_I94_XG_p1 I1_I654_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I654_I94_XG_MP1 (I1_I654_G28_27 I1_I654_gn27 XI1_I654_I94_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I654_I95_XG_MP2 (VDD I1_I654_gn29 I1_I654_G29_28 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I654_I95_XG_MP0 (XI1_I654_I95_XG_p1 I1_I654_pn29 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I654_I95_XG_MP1 (I1_I654_G29_28 I1_I654_gn28 XI1_I654_I95_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I92_XG_MP2 (VDD I1_I608_gn26 I1_I608_G26_25 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I608_I92_XG_MP0 (XI1_I608_I92_XG_p1 I1_I608_pn26 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I608_I92_XG_MP1 (I1_I608_G26_25 I1_I608_gn25 XI1_I608_I92_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I608_I93_XG_MP2 (VDD I1_I608_gn27 I1_I608_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I608_I93_XG_MP0 (XI1_I608_I93_XG_p1 I1_I608_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I608_I93_XG_MP1 (I1_I608_G27_26 I1_I608_gn26 XI1_I608_I93_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I69_XG_MP2 (VDD I1_I1022_gn3 I1_I1022_G3_2 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1022_I69_XG_MP0 (XI1_I1022_I69_XG_p1 I1_I1022_pn3 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1022_I69_XG_MP1 (I1_I1022_G3_2 I1_I1022_gn2 XI1_I1022_I69_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1022_I70_XG_MP2 (VDD I1_I1022_gn4 I1_I1022_G4_3 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI1_I1022_I70_XG_MP0 (XI1_I1022_I70_XG_p1 I1_I1022_pn4 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI1_I1022_I70_XG_MP1 (I1_I1022_G4_3 I1_I1022_gn3 XI1_I1022_I70_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I85_XG_MP2 (VDD I2_I1_I42_gn19 I2_I1_I42_G19_18 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2_I1_I42_I85_XG_MP0 (XI2_I1_I42_I85_XG_p1 I2_I1_I42_pn19 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I85_XG_MP1 (I2_I1_I42_G19_18 I2_I1_I42_gn18 XI2_I1_I42_I85_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I86_XG_MP2 (VDD I2_I1_I42_gn20 I2_I1_I42_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2_I1_I42_I86_XG_MP0 (XI2_I1_I42_I86_XG_p1 I2_I1_I42_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I86_XG_MP1 (I2_I1_I42_G20_19 I2_I1_I42_gn19 XI2_I1_I42_I86_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I148_XG_MP2 (VDD I2_I1_I42_G23_20n I2_I1_I42_G23_16 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2_I1_I42_I148_XG_MP0 (XI2_I1_I42_I148_XG_p1 I2_I1_I42_P23_20n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I148_XG_MP1 (I2_I1_I42_G23_16 I2_I1_I42_G19_16n XI2_I1_I42_I148_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI2_I1_I42_I152_XG_MP2 (VDD I2_I1_I42_G27_24n I2_I1_I42_G27_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI2_I1_I42_I152_XG_MP0 (XI2_I1_I42_I152_XG_p1 I2_I1_I42_P27_24n VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI2_I1_I42_I152_XG_MP1 (I2_I1_I42_G27_20 I2_I1_I42_G23_20n XI2_I1_I42_I152_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I150_XG_MP2 (VDD I0_I1660_gn20 I0_I1660_G20_19 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI0_I1660_I150_XG_MP0 (XI0_I1660_I150_XG_p1 I0_I1660_pn20 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI0_I1660_I150_XG_MP1 (I0_I1660_G20_19 I0_I1660_gn19 XI0_I1660_I150_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I151_XG_MP2 (VDD I0_I1660_gn21 I0_I1660_G21_20 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI0_I1660_I151_XG_MP0 (XI0_I1660_I151_XG_p1 I0_I1660_pn21 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI0_I1660_I151_XG_MP1 (I0_I1660_G21_20 I0_I1660_gn20 XI0_I1660_I151_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I157_XG_MP2 (VDD I0_I1660_gn27 I0_I1660_G27_26 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI0_I1660_I157_XG_MP0 (XI0_I1660_I157_XG_p1 I0_I1660_pn27 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI0_I1660_I157_XG_MP1 (I0_I1660_G27_26 I0_I1660_gn26 XI0_I1660_I157_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I158_XG_MP2 (VDD I0_I1660_gn28 I0_I1660_G28_27 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI0_I1660_I158_XG_MP0 (XI0_I1660_I158_XG_p1 I0_I1660_pn28 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI0_I1660_I158_XG_MP1 (I0_I1660_G28_27 I0_I1660_gn27 XI0_I1660_I158_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I162_XG_MP2 (VDD I0_I1660_gn32 I0_I1660_G32_31 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI0_I1660_I162_XG_MP0 (XI0_I1660_I162_XG_p1 I0_I1660_pn32 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI0_I1660_I162_XG_MP1 (I0_I1660_G32_31 I0_I1660_gn31 XI0_I1660_I162_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I163_XG_MP2 (VDD I0_I1660_gn33 I0_I1660_G33_32 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI0_I1660_I163_XG_MP0 (XI0_I1660_I163_XG_p1 I0_I1660_pn33 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI0_I1660_I163_XG_MP1 (I0_I1660_G33_32 I0_I1660_gn32 XI0_I1660_I163_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I168_XG_MP2 (VDD I0_I1660_gn38 I0_I1660_G38_37 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI0_I1660_I168_XG_MP0 (XI0_I1660_I168_XG_p1 I0_I1660_pn38 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI0_I1660_I168_XG_MP1 (I0_I1660_G38_37 I0_I1660_gn37 XI0_I1660_I168_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI0_I1660_I169_XG_MP2 (VDD I0_I1660_gn39 I0_I1660_G39_38 VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0936p as=0.0816p pd=0.92u ps=1.16u
    I_MXI0_I1660_I169_XG_MP0 (XI0_I1660_I169_XG_p1 I0_I1660_pn39 VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.0936p pd=0.92u ps=0.92u
    I_MXI0_I1660_I169_XG_MP1 (I0_I1660_G39_38 I0_I1660_gn38 XI0_I1660_I169_XG_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I62_MP1 (VDD I1_b17_30 XI1_I1344_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I62_MP5 (I1_I1344_pn30 I1_b17_30 XI1_I1344_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I62_MP4 (XI1_I1344_I62_p1 XI1_I1344_I62_An I1_I1344_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I62_MP2 (VDD I1_p16_29 XI1_I1344_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I62_MP3 (XI1_I1344_I62_p1 XI1_I1344_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I62_MP0 (VDD I1_p16_29 XI1_I1344_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I63_MP1 (VDD I1_b17_31 XI1_I1344_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I63_MP5 (I1_I1344_pn31 I1_b17_31 XI1_I1344_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I63_MP4 (XI1_I1344_I63_p1 XI1_I1344_I63_An I1_I1344_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I63_MP2 (VDD I1_p16_30 XI1_I1344_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I63_MP3 (XI1_I1344_I63_p1 XI1_I1344_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I63_MP0 (VDD I1_p16_30 XI1_I1344_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I233_MP1 (VDD I1_I1298_G29_0 XI1_I1298_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I233_MP5 (I1_p16_30 I1_I1298_G29_0 XI1_I1298_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I233_MP4 (XI1_I1298_I233_p1 XI1_I1298_I233_An I1_p16_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I233_MP2 (VDD I1_I1298_pn30 XI1_I1298_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I233_MP3 (XI1_I1298_I233_p1 XI1_I1298_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I233_MP0 (VDD I1_I1298_pn30 XI1_I1298_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I234_MP1 (VDD I1_c16_m XI1_I1298_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I234_MP5 (I1_p16_31 I1_c16_m XI1_I1298_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I234_MP4 (XI1_I1298_I234_p1 XI1_I1298_I234_An I1_p16_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I234_MP2 (VDD I1_I1298_pn31 XI1_I1298_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I234_MP3 (XI1_I1298_I234_p1 XI1_I1298_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I234_MP0 (VDD I1_I1298_pn31 XI1_I1298_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I232_MP1 (VDD I1_I1298_G28_0 XI1_I1298_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I232_MP5 (I1_p16_29 I1_I1298_G28_0 XI1_I1298_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I232_MP4 (XI1_I1298_I232_p1 XI1_I1298_I232_An I1_p16_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I232_MP2 (VDD I1_I1298_pn29 XI1_I1298_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I232_MP3 (XI1_I1298_I232_p1 XI1_I1298_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I232_MP0 (VDD I1_I1298_pn29 XI1_I1298_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I61_MP1 (VDD I1_b16_29 XI1_I1298_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I61_MP5 (I1_I1298_pn29 I1_b16_29 XI1_I1298_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I61_MP4 (XI1_I1298_I61_p1 XI1_I1298_I61_An I1_I1298_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I61_MP2 (VDD I1_p15_28 XI1_I1298_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I61_MP3 (XI1_I1298_I61_p1 XI1_I1298_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I61_MP0 (VDD I1_p15_28 XI1_I1298_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I62_MP1 (VDD I1_b16_30 XI1_I1298_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I62_MP5 (I1_I1298_pn30 I1_b16_30 XI1_I1298_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I62_MP4 (XI1_I1298_I62_p1 XI1_I1298_I62_An I1_I1298_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I62_MP2 (VDD I1_p15_29 XI1_I1298_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I62_MP3 (XI1_I1298_I62_p1 XI1_I1298_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I62_MP0 (VDD I1_p15_29 XI1_I1298_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I63_MP1 (VDD I1_b16_31 XI1_I1298_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I63_MP5 (I1_I1298_pn31 I1_b16_31 XI1_I1298_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I63_MP4 (XI1_I1298_I63_p1 XI1_I1298_I63_An I1_I1298_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I63_MP2 (VDD I1_p15_30 XI1_I1298_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I63_MP3 (XI1_I1298_I63_p1 XI1_I1298_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I63_MP0 (VDD I1_p15_30 XI1_I1298_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I232_MP1 (VDD I1_I1252_G28_0 XI1_I1252_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I232_MP5 (I1_p15_29 I1_I1252_G28_0 XI1_I1252_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I232_MP4 (XI1_I1252_I232_p1 XI1_I1252_I232_An I1_p15_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I232_MP2 (VDD I1_I1252_pn29 XI1_I1252_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I232_MP3 (XI1_I1252_I232_p1 XI1_I1252_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I232_MP0 (VDD I1_I1252_pn29 XI1_I1252_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I234_MP1 (VDD I1_c15_m XI1_I1252_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I234_MP5 (I1_p15_31 I1_c15_m XI1_I1252_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I234_MP4 (XI1_I1252_I234_p1 XI1_I1252_I234_An I1_p15_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I234_MP2 (VDD I1_I1252_pn31 XI1_I1252_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I234_MP3 (XI1_I1252_I234_p1 XI1_I1252_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I234_MP0 (VDD I1_I1252_pn31 XI1_I1252_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I231_MP1 (VDD I1_I1252_G27_0 XI1_I1252_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I231_MP5 (I1_p15_28 I1_I1252_G27_0 XI1_I1252_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I231_MP4 (XI1_I1252_I231_p1 XI1_I1252_I231_An I1_p15_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I231_MP2 (VDD I1_I1252_pn28 XI1_I1252_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I231_MP3 (XI1_I1252_I231_p1 XI1_I1252_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I231_MP0 (VDD I1_I1252_pn28 XI1_I1252_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I233_MP1 (VDD I1_I1252_G29_0 XI1_I1252_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I233_MP5 (I1_p15_30 I1_I1252_G29_0 XI1_I1252_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I233_MP4 (XI1_I1252_I233_p1 XI1_I1252_I233_An I1_p15_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I233_MP2 (VDD I1_I1252_pn30 XI1_I1252_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I233_MP3 (XI1_I1252_I233_p1 XI1_I1252_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I233_MP0 (VDD I1_I1252_pn30 XI1_I1252_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I60_MP1 (VDD I1_b15_28 XI1_I1252_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I60_MP5 (I1_I1252_pn28 I1_b15_28 XI1_I1252_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I60_MP4 (XI1_I1252_I60_p1 XI1_I1252_I60_An I1_I1252_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I60_MP2 (VDD I1_p14_27 XI1_I1252_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I60_MP3 (XI1_I1252_I60_p1 XI1_I1252_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I60_MP0 (VDD I1_p14_27 XI1_I1252_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I61_MP1 (VDD I1_b15_29 XI1_I1252_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I61_MP5 (I1_I1252_pn29 I1_b15_29 XI1_I1252_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I61_MP4 (XI1_I1252_I61_p1 XI1_I1252_I61_An I1_I1252_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I61_MP2 (VDD I1_p14_28 XI1_I1252_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I61_MP3 (XI1_I1252_I61_p1 XI1_I1252_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I61_MP0 (VDD I1_p14_28 XI1_I1252_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I63_MP1 (VDD I1_b15_31 XI1_I1252_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I63_MP5 (I1_I1252_pn31 I1_b15_31 XI1_I1252_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I63_MP4 (XI1_I1252_I63_p1 XI1_I1252_I63_An I1_I1252_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I63_MP2 (VDD I1_p14_30 XI1_I1252_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I63_MP3 (XI1_I1252_I63_p1 XI1_I1252_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I63_MP0 (VDD I1_p14_30 XI1_I1252_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I62_MP1 (VDD I1_b15_30 XI1_I1252_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I62_MP5 (I1_I1252_pn30 I1_b15_30 XI1_I1252_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I62_MP4 (XI1_I1252_I62_p1 XI1_I1252_I62_An I1_I1252_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I62_MP2 (VDD I1_p14_29 XI1_I1252_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I62_MP3 (XI1_I1252_I62_p1 XI1_I1252_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I62_MP0 (VDD I1_p14_29 XI1_I1252_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I231_MP1 (VDD I1_I1206_G27_0 XI1_I1206_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I231_MP5 (I1_p14_28 I1_I1206_G27_0 XI1_I1206_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I231_MP4 (XI1_I1206_I231_p1 XI1_I1206_I231_An I1_p14_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I231_MP2 (VDD I1_I1206_pn28 XI1_I1206_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I231_MP3 (XI1_I1206_I231_p1 XI1_I1206_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I231_MP0 (VDD I1_I1206_pn28 XI1_I1206_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I61_MP1 (VDD I1_b14_29 XI1_I1206_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I61_MP5 (I1_I1206_pn29 I1_b14_29 XI1_I1206_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I61_MP4 (XI1_I1206_I61_p1 XI1_I1206_I61_An I1_I1206_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I61_MP2 (VDD I1_p13_28 XI1_I1206_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I61_MP3 (XI1_I1206_I61_p1 XI1_I1206_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I61_MP0 (VDD I1_p13_28 XI1_I1206_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I232_MP1 (VDD I1_I1206_G28_0 XI1_I1206_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I232_MP5 (I1_p14_29 I1_I1206_G28_0 XI1_I1206_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I232_MP4 (XI1_I1206_I232_p1 XI1_I1206_I232_An I1_p14_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I232_MP2 (VDD I1_I1206_pn29 XI1_I1206_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I232_MP3 (XI1_I1206_I232_p1 XI1_I1206_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I232_MP0 (VDD I1_I1206_pn29 XI1_I1206_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I60_MP1 (VDD I1_b14_28 XI1_I1206_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I60_MP5 (I1_I1206_pn28 I1_b14_28 XI1_I1206_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I60_MP4 (XI1_I1206_I60_p1 XI1_I1206_I60_An I1_I1206_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I60_MP2 (VDD I1_p13_27 XI1_I1206_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I60_MP3 (XI1_I1206_I60_p1 XI1_I1206_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I60_MP0 (VDD I1_p13_27 XI1_I1206_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I59_MP1 (VDD I1_b14_27 XI1_I1206_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I59_MP5 (I1_I1206_pn27 I1_b14_27 XI1_I1206_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I59_MP4 (XI1_I1206_I59_p1 XI1_I1206_I59_An I1_I1206_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I59_MP2 (VDD I1_p13_26 XI1_I1206_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I59_MP3 (XI1_I1206_I59_p1 XI1_I1206_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I59_MP0 (VDD I1_p13_26 XI1_I1206_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I230_MP1 (VDD I1_I1206_G26_0 XI1_I1206_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I230_MP5 (I1_p14_27 I1_I1206_G26_0 XI1_I1206_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I230_MP4 (XI1_I1206_I230_p1 XI1_I1206_I230_An I1_p14_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I230_MP2 (VDD I1_I1206_pn27 XI1_I1206_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I230_MP3 (XI1_I1206_I230_p1 XI1_I1206_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I230_MP0 (VDD I1_I1206_pn27 XI1_I1206_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I62_MP1 (VDD I1_b6_30 XI1_I838_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I62_MP5 (I1_I838_pn30 I1_b6_30 XI1_I838_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I62_MP4 (XI1_I838_I62_p1 XI1_I838_I62_An I1_I838_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I62_MP2 (VDD I1_p5_29 XI1_I838_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I62_MP3 (XI1_I838_I62_p1 XI1_I838_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I62_MP0 (VDD I1_p5_29 XI1_I838_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I233_MP1 (VDD I1_I792_G29_0 XI1_I792_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I233_MP5 (I1_p5_30 I1_I792_G29_0 XI1_I792_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I233_MP4 (XI1_I792_I233_p1 XI1_I792_I233_An I1_p5_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I233_MP2 (VDD I1_I792_pn30 XI1_I792_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I233_MP3 (XI1_I792_I233_p1 XI1_I792_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I233_MP0 (VDD I1_I792_pn30 XI1_I792_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I231_MP1 (VDD I1_I792_G27_0 XI1_I792_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I231_MP5 (I1_p5_28 I1_I792_G27_0 XI1_I792_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I231_MP4 (XI1_I792_I231_p1 XI1_I792_I231_An I1_p5_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I231_MP2 (VDD I1_I792_pn28 XI1_I792_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I231_MP3 (XI1_I792_I231_p1 XI1_I792_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I231_MP0 (VDD I1_I792_pn28 XI1_I792_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I232_MP1 (VDD I1_I792_G28_0 XI1_I792_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I232_MP5 (I1_p5_29 I1_I792_G28_0 XI1_I792_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I232_MP4 (XI1_I792_I232_p1 XI1_I792_I232_An I1_p5_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I232_MP2 (VDD I1_I792_pn29 XI1_I792_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I232_MP3 (XI1_I792_I232_p1 XI1_I792_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I232_MP0 (VDD I1_I792_pn29 XI1_I792_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I234_MP1 (VDD I1_c5_m XI1_I792_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I234_MP5 (I1_p5_31 I1_c5_m XI1_I792_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I234_MP4 (XI1_I792_I234_p1 XI1_I792_I234_An I1_p5_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I234_MP2 (VDD I1_I792_pn31 XI1_I792_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I234_MP3 (XI1_I792_I234_p1 XI1_I792_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I234_MP0 (VDD I1_I792_pn31 XI1_I792_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I62_MP1 (VDD I1_b5_30 XI1_I792_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I62_MP5 (I1_I792_pn30 I1_b5_30 XI1_I792_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I62_MP4 (XI1_I792_I62_p1 XI1_I792_I62_An I1_I792_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I62_MP2 (VDD I1_p4_29 XI1_I792_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I62_MP3 (XI1_I792_I62_p1 XI1_I792_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I62_MP0 (VDD I1_p4_29 XI1_I792_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I63_MP1 (VDD I1_b5_31 XI1_I792_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I63_MP5 (I1_I792_pn31 I1_b5_31 XI1_I792_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I63_MP4 (XI1_I792_I63_p1 XI1_I792_I63_An I1_I792_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I63_MP2 (VDD I1_p4_30 XI1_I792_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I63_MP3 (XI1_I792_I63_p1 XI1_I792_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I63_MP0 (VDD I1_p4_30 XI1_I792_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I60_MP1 (VDD I1_b5_28 XI1_I792_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I60_MP5 (I1_I792_pn28 I1_b5_28 XI1_I792_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I60_MP4 (XI1_I792_I60_p1 XI1_I792_I60_An I1_I792_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I60_MP2 (VDD I1_p4_27 XI1_I792_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I60_MP3 (XI1_I792_I60_p1 XI1_I792_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I60_MP0 (VDD I1_p4_27 XI1_I792_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I61_MP1 (VDD I1_b5_29 XI1_I792_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I61_MP5 (I1_I792_pn29 I1_b5_29 XI1_I792_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I61_MP4 (XI1_I792_I61_p1 XI1_I792_I61_An I1_I792_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I61_MP2 (VDD I1_p4_28 XI1_I792_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I61_MP3 (XI1_I792_I61_p1 XI1_I792_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I61_MP0 (VDD I1_p4_28 XI1_I792_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I61_MP1 (VDD I1_b17_29 XI1_I1344_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I61_MP5 (I1_I1344_pn29 I1_b17_29 XI1_I1344_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I61_MP4 (XI1_I1344_I61_p1 XI1_I1344_I61_An I1_I1344_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I61_MP2 (VDD I1_p16_28 XI1_I1344_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I61_MP3 (XI1_I1344_I61_p1 XI1_I1344_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I61_MP0 (VDD I1_p16_28 XI1_I1344_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I231_MP1 (VDD I1_I1298_G27_0 XI1_I1298_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I231_MP5 (I1_p16_28 I1_I1298_G27_0 XI1_I1298_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I231_MP4 (XI1_I1298_I231_p1 XI1_I1298_I231_An I1_p16_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I231_MP2 (VDD I1_I1298_pn28 XI1_I1298_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I231_MP3 (XI1_I1298_I231_p1 XI1_I1298_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I231_MP0 (VDD I1_I1298_pn28 XI1_I1298_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I230_MP1 (VDD I1_I1298_G26_0 XI1_I1298_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I230_MP5 (I1_p16_27 I1_I1298_G26_0 XI1_I1298_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I230_MP4 (XI1_I1298_I230_p1 XI1_I1298_I230_An I1_p16_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I230_MP2 (VDD I1_I1298_pn27 XI1_I1298_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I230_MP3 (XI1_I1298_I230_p1 XI1_I1298_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I230_MP0 (VDD I1_I1298_pn27 XI1_I1298_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I60_MP1 (VDD I1_b16_28 XI1_I1298_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I60_MP5 (I1_I1298_pn28 I1_b16_28 XI1_I1298_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I60_MP4 (XI1_I1298_I60_p1 XI1_I1298_I60_An I1_I1298_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I60_MP2 (VDD I1_p15_27 XI1_I1298_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I60_MP3 (XI1_I1298_I60_p1 XI1_I1298_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I60_MP0 (VDD I1_p15_27 XI1_I1298_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I59_MP1 (VDD I1_b16_27 XI1_I1298_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I59_MP5 (I1_I1298_pn27 I1_b16_27 XI1_I1298_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I59_MP4 (XI1_I1298_I59_p1 XI1_I1298_I59_An I1_I1298_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I59_MP2 (VDD I1_p15_26 XI1_I1298_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I59_MP3 (XI1_I1298_I59_p1 XI1_I1298_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I59_MP0 (VDD I1_p15_26 XI1_I1298_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I230_MP1 (VDD I1_I1252_G26_0 XI1_I1252_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I230_MP5 (I1_p15_27 I1_I1252_G26_0 XI1_I1252_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I230_MP4 (XI1_I1252_I230_p1 XI1_I1252_I230_An I1_p15_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I230_MP2 (VDD I1_I1252_pn27 XI1_I1252_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I230_MP3 (XI1_I1252_I230_p1 XI1_I1252_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I230_MP0 (VDD I1_I1252_pn27 XI1_I1252_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I229_MP1 (VDD I1_I1252_G25_0 XI1_I1252_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I229_MP5 (I1_p15_26 I1_I1252_G25_0 XI1_I1252_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I229_MP4 (XI1_I1252_I229_p1 XI1_I1252_I229_An I1_p15_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I229_MP2 (VDD I1_I1252_pn26 XI1_I1252_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I229_MP3 (XI1_I1252_I229_p1 XI1_I1252_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I229_MP0 (VDD I1_I1252_pn26 XI1_I1252_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I59_MP1 (VDD I1_b15_27 XI1_I1252_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I59_MP5 (I1_I1252_pn27 I1_b15_27 XI1_I1252_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I59_MP4 (XI1_I1252_I59_p1 XI1_I1252_I59_An I1_I1252_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I59_MP2 (VDD I1_p14_26 XI1_I1252_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I59_MP3 (XI1_I1252_I59_p1 XI1_I1252_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I59_MP0 (VDD I1_p14_26 XI1_I1252_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I63_MP1 (VDD I1_b14_31 XI1_I1206_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I63_MP5 (I1_I1206_pn31 I1_b14_31 XI1_I1206_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I63_MP4 (XI1_I1206_I63_p1 XI1_I1206_I63_An I1_I1206_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I63_MP2 (VDD I1_p13_30 XI1_I1206_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I63_MP3 (XI1_I1206_I63_p1 XI1_I1206_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I63_MP0 (VDD I1_p13_30 XI1_I1206_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I62_MP1 (VDD I1_b14_30 XI1_I1206_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I62_MP5 (I1_I1206_pn30 I1_b14_30 XI1_I1206_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I62_MP4 (XI1_I1206_I62_p1 XI1_I1206_I62_An I1_I1206_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I62_MP2 (VDD I1_p13_29 XI1_I1206_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I62_MP3 (XI1_I1206_I62_p1 XI1_I1206_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I62_MP0 (VDD I1_p13_29 XI1_I1206_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I234_MP1 (VDD I1_c14_m XI1_I1206_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I234_MP5 (I1_p14_31 I1_c14_m XI1_I1206_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I234_MP4 (XI1_I1206_I234_p1 XI1_I1206_I234_An I1_p14_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I234_MP2 (VDD I1_I1206_pn31 XI1_I1206_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I234_MP3 (XI1_I1206_I234_p1 XI1_I1206_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I234_MP0 (VDD I1_I1206_pn31 XI1_I1206_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I233_MP1 (VDD I1_I1206_G29_0 XI1_I1206_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I233_MP5 (I1_p14_30 I1_I1206_G29_0 XI1_I1206_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I233_MP4 (XI1_I1206_I233_p1 XI1_I1206_I233_An I1_p14_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I233_MP2 (VDD I1_I1206_pn30 XI1_I1206_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I233_MP3 (XI1_I1206_I233_p1 XI1_I1206_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I233_MP0 (VDD I1_I1206_pn30 XI1_I1206_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I229_MP1 (VDD I1_I1206_G25_0 XI1_I1206_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I229_MP5 (I1_p14_26 I1_I1206_G25_0 XI1_I1206_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I229_MP4 (XI1_I1206_I229_p1 XI1_I1206_I229_An I1_p14_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I229_MP2 (VDD I1_I1206_pn26 XI1_I1206_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I229_MP3 (XI1_I1206_I229_p1 XI1_I1206_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I229_MP0 (VDD I1_I1206_pn26 XI1_I1206_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I61_MP1 (VDD I1_b6_29 XI1_I838_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I61_MP5 (I1_I838_pn29 I1_b6_29 XI1_I838_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I61_MP4 (XI1_I838_I61_p1 XI1_I838_I61_An I1_I838_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I61_MP2 (VDD I1_p5_28 XI1_I838_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I61_MP3 (XI1_I838_I61_p1 XI1_I838_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I61_MP0 (VDD I1_p5_28 XI1_I838_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I59_MP1 (VDD I1_b6_27 XI1_I838_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I59_MP5 (I1_I838_pn27 I1_b6_27 XI1_I838_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I59_MP4 (XI1_I838_I59_p1 XI1_I838_I59_An I1_I838_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I59_MP2 (VDD I1_p5_26 XI1_I838_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I59_MP3 (XI1_I838_I59_p1 XI1_I838_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I59_MP0 (VDD I1_p5_26 XI1_I838_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I63_MP1 (VDD I1_b6_31 XI1_I838_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I63_MP5 (I1_I838_pn31 I1_b6_31 XI1_I838_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I63_MP4 (XI1_I838_I63_p1 XI1_I838_I63_An I1_I838_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I63_MP2 (VDD I1_p5_30 XI1_I838_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I63_MP3 (XI1_I838_I63_p1 XI1_I838_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I63_MP0 (VDD I1_p5_30 XI1_I838_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I57_MP1 (VDD I1_b6_25 XI1_I838_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I57_MP5 (I1_I838_pn25 I1_b6_25 XI1_I838_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I57_MP4 (XI1_I838_I57_p1 XI1_I838_I57_An I1_I838_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I57_MP2 (VDD I1_p5_24 XI1_I838_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I57_MP3 (XI1_I838_I57_p1 XI1_I838_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I57_MP0 (VDD I1_p5_24 XI1_I838_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I227_MP1 (VDD I1_I838_G23_0 XI1_I838_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I227_MP5 (I1_p6_24 I1_I838_G23_0 XI1_I838_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I227_MP4 (XI1_I838_I227_p1 XI1_I838_I227_An I1_p6_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I227_MP2 (VDD I1_I838_pn24 XI1_I838_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I227_MP3 (XI1_I838_I227_p1 XI1_I838_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I227_MP0 (VDD I1_I838_pn24 XI1_I838_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I225_MP1 (VDD I1_I838_G21_0 XI1_I838_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I225_MP5 (I1_p6_22 I1_I838_G21_0 XI1_I838_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I225_MP4 (XI1_I838_I225_p1 XI1_I838_I225_An I1_p6_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I225_MP2 (VDD I1_I838_pn22 XI1_I838_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I225_MP3 (XI1_I838_I225_p1 XI1_I838_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I225_MP0 (VDD I1_I838_pn22 XI1_I838_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I225_MP1 (VDD I1_I792_G21_0 XI1_I792_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I225_MP5 (I1_p5_22 I1_I792_G21_0 XI1_I792_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I225_MP4 (XI1_I792_I225_p1 XI1_I792_I225_An I1_p5_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I225_MP2 (VDD I1_I792_pn22 XI1_I792_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I225_MP3 (XI1_I792_I225_p1 XI1_I792_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I225_MP0 (VDD I1_I792_pn22 XI1_I792_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I229_MP1 (VDD I1_I792_G25_0 XI1_I792_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I229_MP5 (I1_p5_26 I1_I792_G25_0 XI1_I792_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I229_MP4 (XI1_I792_I229_p1 XI1_I792_I229_An I1_p5_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I229_MP2 (VDD I1_I792_pn26 XI1_I792_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I229_MP3 (XI1_I792_I229_p1 XI1_I792_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I229_MP0 (VDD I1_I792_pn26 XI1_I792_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I227_MP1 (VDD I1_I792_G23_0 XI1_I792_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I227_MP5 (I1_p5_24 I1_I792_G23_0 XI1_I792_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I227_MP4 (XI1_I792_I227_p1 XI1_I792_I227_An I1_p5_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I227_MP2 (VDD I1_I792_pn24 XI1_I792_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I227_MP3 (XI1_I792_I227_p1 XI1_I792_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I227_MP0 (VDD I1_I792_pn24 XI1_I792_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I230_MP1 (VDD I1_I792_G26_0 XI1_I792_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I230_MP5 (I1_p5_27 I1_I792_G26_0 XI1_I792_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I230_MP4 (XI1_I792_I230_p1 XI1_I792_I230_An I1_p5_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I230_MP2 (VDD I1_I792_pn27 XI1_I792_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I230_MP3 (XI1_I792_I230_p1 XI1_I792_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I230_MP0 (VDD I1_I792_pn27 XI1_I792_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I58_MP1 (VDD I1_b5_26 XI1_I792_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I58_MP5 (I1_I792_pn26 I1_b5_26 XI1_I792_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I58_MP4 (XI1_I792_I58_p1 XI1_I792_I58_An I1_I792_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I58_MP2 (VDD I1_p4_25 XI1_I792_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I58_MP3 (XI1_I792_I58_p1 XI1_I792_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I58_MP0 (VDD I1_p4_25 XI1_I792_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I57_MP1 (VDD I1_b5_25 XI1_I792_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I57_MP5 (I1_I792_pn25 I1_b5_25 XI1_I792_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I57_MP4 (XI1_I792_I57_p1 XI1_I792_I57_An I1_I792_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I57_MP2 (VDD I1_p4_24 XI1_I792_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I57_MP3 (XI1_I792_I57_p1 XI1_I792_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I57_MP0 (VDD I1_p4_24 XI1_I792_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I59_MP1 (VDD I1_b5_27 XI1_I792_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I59_MP5 (I1_I792_pn27 I1_b5_27 XI1_I792_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I59_MP4 (XI1_I792_I59_p1 XI1_I792_I59_An I1_I792_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I59_MP2 (VDD I1_p4_26 XI1_I792_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I59_MP3 (XI1_I792_I59_p1 XI1_I792_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I59_MP0 (VDD I1_p4_26 XI1_I792_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I231_MP1 (VDD I1_I746_G27_0 XI1_I746_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I231_MP5 (I1_p4_28 I1_I746_G27_0 XI1_I746_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I231_MP4 (XI1_I746_I231_p1 XI1_I746_I231_An I1_p4_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I231_MP2 (VDD I1_I746_pn28 XI1_I746_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I231_MP3 (XI1_I746_I231_p1 XI1_I746_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I231_MP0 (VDD I1_I746_pn28 XI1_I746_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I60_MP1 (VDD I1_b17_28 XI1_I1344_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I60_MP5 (I1_I1344_pn28 I1_b17_28 XI1_I1344_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I60_MP4 (XI1_I1344_I60_p1 XI1_I1344_I60_An I1_I1344_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I60_MP2 (VDD I1_p16_27 XI1_I1344_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I60_MP3 (XI1_I1344_I60_p1 XI1_I1344_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I60_MP0 (VDD I1_p16_27 XI1_I1344_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I231_MP1 (VDD I1_I1344_G27_0 XI1_I1344_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I231_MP5 (I1_p17_28 I1_I1344_G27_0 XI1_I1344_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I231_MP4 (XI1_I1344_I231_p1 XI1_I1344_I231_An I1_p17_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I231_MP2 (VDD I1_I1344_pn28 XI1_I1344_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I231_MP3 (XI1_I1344_I231_p1 XI1_I1344_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I231_MP0 (VDD I1_I1344_pn28 XI1_I1344_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I233_MP1 (VDD I1_I1344_G29_0 XI1_I1344_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I233_MP5 (I1_p17_30 I1_I1344_G29_0 XI1_I1344_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I233_MP4 (XI1_I1344_I233_p1 XI1_I1344_I233_An I1_p17_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I233_MP2 (VDD I1_I1344_pn30 XI1_I1344_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I233_MP3 (XI1_I1344_I233_p1 XI1_I1344_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I233_MP0 (VDD I1_I1344_pn30 XI1_I1344_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I227_MP1 (VDD I1_I1344_G23_0 XI1_I1344_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I227_MP5 (I1_p17_24 I1_I1344_G23_0 XI1_I1344_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I227_MP4 (XI1_I1344_I227_p1 XI1_I1344_I227_An I1_p17_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I227_MP2 (VDD I1_I1344_pn24 XI1_I1344_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I227_MP3 (XI1_I1344_I227_p1 XI1_I1344_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I227_MP0 (VDD I1_I1344_pn24 XI1_I1344_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I229_MP1 (VDD I1_I1298_G25_0 XI1_I1298_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I229_MP5 (I1_p16_26 I1_I1298_G25_0 XI1_I1298_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I229_MP4 (XI1_I1298_I229_p1 XI1_I1298_I229_An I1_p16_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I229_MP2 (VDD I1_I1298_pn26 XI1_I1298_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I229_MP3 (XI1_I1298_I229_p1 XI1_I1298_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I229_MP0 (VDD I1_I1298_pn26 XI1_I1298_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I57_MP1 (VDD I1_b16_25 XI1_I1298_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I57_MP5 (I1_I1298_pn25 I1_b16_25 XI1_I1298_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I57_MP4 (XI1_I1298_I57_p1 XI1_I1298_I57_An I1_I1298_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I57_MP2 (VDD I1_p15_24 XI1_I1298_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I57_MP3 (XI1_I1298_I57_p1 XI1_I1298_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I57_MP0 (VDD I1_p15_24 XI1_I1298_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I58_MP1 (VDD I1_b16_26 XI1_I1298_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I58_MP5 (I1_I1298_pn26 I1_b16_26 XI1_I1298_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I58_MP4 (XI1_I1298_I58_p1 XI1_I1298_I58_An I1_I1298_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I58_MP2 (VDD I1_p15_25 XI1_I1298_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I58_MP3 (XI1_I1298_I58_p1 XI1_I1298_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I58_MP0 (VDD I1_p15_25 XI1_I1298_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I56_MP1 (VDD I1_b16_24 XI1_I1298_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I56_MP5 (I1_I1298_pn24 I1_b16_24 XI1_I1298_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I56_MP4 (XI1_I1298_I56_p1 XI1_I1298_I56_An I1_I1298_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I56_MP2 (VDD I1_p15_23 XI1_I1298_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I56_MP3 (XI1_I1298_I56_p1 XI1_I1298_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I56_MP0 (VDD I1_p15_23 XI1_I1298_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I228_MP1 (VDD I1_I1252_G24_0 XI1_I1252_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I228_MP5 (I1_p15_25 I1_I1252_G24_0 XI1_I1252_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I228_MP4 (XI1_I1252_I228_p1 XI1_I1252_I228_An I1_p15_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I228_MP2 (VDD I1_I1252_pn25 XI1_I1252_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I228_MP3 (XI1_I1252_I228_p1 XI1_I1252_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I228_MP0 (VDD I1_I1252_pn25 XI1_I1252_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I227_MP1 (VDD I1_I1252_G23_0 XI1_I1252_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I227_MP5 (I1_p15_24 I1_I1252_G23_0 XI1_I1252_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I227_MP4 (XI1_I1252_I227_p1 XI1_I1252_I227_An I1_p15_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I227_MP2 (VDD I1_I1252_pn24 XI1_I1252_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I227_MP3 (XI1_I1252_I227_p1 XI1_I1252_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I227_MP0 (VDD I1_I1252_pn24 XI1_I1252_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I56_MP1 (VDD I1_b15_24 XI1_I1252_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I56_MP5 (I1_I1252_pn24 I1_b15_24 XI1_I1252_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I56_MP4 (XI1_I1252_I56_p1 XI1_I1252_I56_An I1_I1252_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I56_MP2 (VDD I1_p14_23 XI1_I1252_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I56_MP3 (XI1_I1252_I56_p1 XI1_I1252_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I56_MP0 (VDD I1_p14_23 XI1_I1252_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I58_MP1 (VDD I1_b15_26 XI1_I1252_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I58_MP5 (I1_I1252_pn26 I1_b15_26 XI1_I1252_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I58_MP4 (XI1_I1252_I58_p1 XI1_I1252_I58_An I1_I1252_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I58_MP2 (VDD I1_p14_25 XI1_I1252_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I58_MP3 (XI1_I1252_I58_p1 XI1_I1252_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I58_MP0 (VDD I1_p14_25 XI1_I1252_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I57_MP1 (VDD I1_b15_25 XI1_I1252_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I57_MP5 (I1_I1252_pn25 I1_b15_25 XI1_I1252_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I57_MP4 (XI1_I1252_I57_p1 XI1_I1252_I57_An I1_I1252_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I57_MP2 (VDD I1_p14_24 XI1_I1252_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I57_MP3 (XI1_I1252_I57_p1 XI1_I1252_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I57_MP0 (VDD I1_p14_24 XI1_I1252_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I227_MP1 (VDD I1_I1206_G23_0 XI1_I1206_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I227_MP5 (I1_p14_24 I1_I1206_G23_0 XI1_I1206_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I227_MP4 (XI1_I1206_I227_p1 XI1_I1206_I227_An I1_p14_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I227_MP2 (VDD I1_I1206_pn24 XI1_I1206_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I227_MP3 (XI1_I1206_I227_p1 XI1_I1206_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I227_MP0 (VDD I1_I1206_pn24 XI1_I1206_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I58_MP1 (VDD I1_b14_26 XI1_I1206_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I58_MP5 (I1_I1206_pn26 I1_b14_26 XI1_I1206_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I58_MP4 (XI1_I1206_I58_p1 XI1_I1206_I58_An I1_I1206_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I58_MP2 (VDD I1_p13_25 XI1_I1206_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I58_MP3 (XI1_I1206_I58_p1 XI1_I1206_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I58_MP0 (VDD I1_p13_25 XI1_I1206_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I228_MP1 (VDD I1_I1206_G24_0 XI1_I1206_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I228_MP5 (I1_p14_25 I1_I1206_G24_0 XI1_I1206_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I228_MP4 (XI1_I1206_I228_p1 XI1_I1206_I228_An I1_p14_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I228_MP2 (VDD I1_I1206_pn25 XI1_I1206_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I228_MP3 (XI1_I1206_I228_p1 XI1_I1206_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I228_MP0 (VDD I1_I1206_pn25 XI1_I1206_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I60_MP1 (VDD I1_b6_28 XI1_I838_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I60_MP5 (I1_I838_pn28 I1_b6_28 XI1_I838_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I60_MP4 (XI1_I838_I60_p1 XI1_I838_I60_An I1_I838_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I60_MP2 (VDD I1_p5_27 XI1_I838_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I60_MP3 (XI1_I838_I60_p1 XI1_I838_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I60_MP0 (VDD I1_p5_27 XI1_I838_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I233_MP1 (VDD I1_I838_G29_0 XI1_I838_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I233_MP5 (I1_p6_30 I1_I838_G29_0 XI1_I838_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I233_MP4 (XI1_I838_I233_p1 XI1_I838_I233_An I1_p6_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I233_MP2 (VDD I1_I838_pn30 XI1_I838_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I233_MP3 (XI1_I838_I233_p1 XI1_I838_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I233_MP0 (VDD I1_I838_pn30 XI1_I838_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I56_MP1 (VDD I1_b6_24 XI1_I838_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I56_MP5 (I1_I838_pn24 I1_b6_24 XI1_I838_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I56_MP4 (XI1_I838_I56_p1 XI1_I838_I56_An I1_I838_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I56_MP2 (VDD I1_p5_23 XI1_I838_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I56_MP3 (XI1_I838_I56_p1 XI1_I838_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I56_MP0 (VDD I1_p5_23 XI1_I838_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I55_MP1 (VDD I1_b6_23 XI1_I838_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I55_MP5 (I1_I838_pn23 I1_b6_23 XI1_I838_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I55_MP4 (XI1_I838_I55_p1 XI1_I838_I55_An I1_I838_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I55_MP2 (VDD I1_p5_22 XI1_I838_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I55_MP3 (XI1_I838_I55_p1 XI1_I838_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I55_MP0 (VDD I1_p5_22 XI1_I838_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I53_MP1 (VDD I1_b6_21 XI1_I838_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I53_MP5 (I1_I838_pn21 I1_b6_21 XI1_I838_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I53_MP4 (XI1_I838_I53_p1 XI1_I838_I53_An I1_I838_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I53_MP2 (VDD I1_p5_20 XI1_I838_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I53_MP3 (XI1_I838_I53_p1 XI1_I838_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I53_MP0 (VDD I1_p5_20 XI1_I838_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I223_MP1 (VDD I1_I838_G19_0 XI1_I838_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I223_MP5 (I1_p6_20 I1_I838_G19_0 XI1_I838_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I223_MP4 (XI1_I838_I223_p1 XI1_I838_I223_An I1_p6_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I223_MP2 (VDD I1_I838_pn20 XI1_I838_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I223_MP3 (XI1_I838_I223_p1 XI1_I838_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I223_MP0 (VDD I1_I838_pn20 XI1_I838_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I221_MP1 (VDD I1_I838_G17_0 XI1_I838_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I221_MP5 (I1_p6_18 I1_I838_G17_0 XI1_I838_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I221_MP4 (XI1_I838_I221_p1 XI1_I838_I221_An I1_p6_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I221_MP2 (VDD I1_I838_pn18 XI1_I838_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I221_MP3 (XI1_I838_I221_p1 XI1_I838_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I221_MP0 (VDD I1_I838_pn18 XI1_I838_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I223_MP1 (VDD I1_I792_G19_0 XI1_I792_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I223_MP5 (I1_p5_20 I1_I792_G19_0 XI1_I792_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I223_MP4 (XI1_I792_I223_p1 XI1_I792_I223_An I1_p5_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I223_MP2 (VDD I1_I792_pn20 XI1_I792_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I223_MP3 (XI1_I792_I223_p1 XI1_I792_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I223_MP0 (VDD I1_I792_pn20 XI1_I792_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I228_MP1 (VDD I1_I792_G24_0 XI1_I792_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I228_MP5 (I1_p5_25 I1_I792_G24_0 XI1_I792_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I228_MP4 (XI1_I792_I228_p1 XI1_I792_I228_An I1_p5_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I228_MP2 (VDD I1_I792_pn25 XI1_I792_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I228_MP3 (XI1_I792_I228_p1 XI1_I792_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I228_MP0 (VDD I1_I792_pn25 XI1_I792_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I226_MP1 (VDD I1_I792_G22_0 XI1_I792_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I226_MP5 (I1_p5_23 I1_I792_G22_0 XI1_I792_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I226_MP4 (XI1_I792_I226_p1 XI1_I792_I226_An I1_p5_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I226_MP2 (VDD I1_I792_pn23 XI1_I792_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I226_MP3 (XI1_I792_I226_p1 XI1_I792_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I226_MP0 (VDD I1_I792_pn23 XI1_I792_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I55_MP1 (VDD I1_b5_23 XI1_I792_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I55_MP5 (I1_I792_pn23 I1_b5_23 XI1_I792_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I55_MP4 (XI1_I792_I55_p1 XI1_I792_I55_An I1_I792_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I55_MP2 (VDD I1_p4_22 XI1_I792_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I55_MP3 (XI1_I792_I55_p1 XI1_I792_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I55_MP0 (VDD I1_p4_22 XI1_I792_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I56_MP1 (VDD I1_b5_24 XI1_I792_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I56_MP5 (I1_I792_pn24 I1_b5_24 XI1_I792_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I56_MP4 (XI1_I792_I56_p1 XI1_I792_I56_An I1_I792_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I56_MP2 (VDD I1_p4_23 XI1_I792_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I56_MP3 (XI1_I792_I56_p1 XI1_I792_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I56_MP0 (VDD I1_p4_23 XI1_I792_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I226_MP1 (VDD I1_I746_G22_0 XI1_I746_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I226_MP5 (I1_p4_23 I1_I746_G22_0 XI1_I746_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I226_MP4 (XI1_I746_I226_p1 XI1_I746_I226_An I1_p4_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I226_MP2 (VDD I1_I746_pn23 XI1_I746_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I226_MP3 (XI1_I746_I226_p1 XI1_I746_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I226_MP0 (VDD I1_I746_pn23 XI1_I746_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I230_MP1 (VDD I1_I746_G26_0 XI1_I746_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I230_MP5 (I1_p4_27 I1_I746_G26_0 XI1_I746_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I230_MP4 (XI1_I746_I230_p1 XI1_I746_I230_An I1_p4_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I230_MP2 (VDD I1_I746_pn27 XI1_I746_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I230_MP3 (XI1_I746_I230_p1 XI1_I746_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I230_MP0 (VDD I1_I746_pn27 XI1_I746_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I229_MP1 (VDD I1_I746_G25_0 XI1_I746_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I229_MP5 (I1_p4_26 I1_I746_G25_0 XI1_I746_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I229_MP4 (XI1_I746_I229_p1 XI1_I746_I229_An I1_p4_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I229_MP2 (VDD I1_I746_pn26 XI1_I746_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I229_MP3 (XI1_I746_I229_p1 XI1_I746_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I229_MP0 (VDD I1_I746_pn26 XI1_I746_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I234_MP1 (VDD I1_c4_m XI1_I746_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I234_MP5 (I1_p4_31 I1_c4_m XI1_I746_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I234_MP4 (XI1_I746_I234_p1 XI1_I746_I234_An I1_p4_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I234_MP2 (VDD I1_I746_pn31 XI1_I746_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I234_MP3 (XI1_I746_I234_p1 XI1_I746_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I234_MP0 (VDD I1_I746_pn31 XI1_I746_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I233_MP1 (VDD I1_I746_G29_0 XI1_I746_I233_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I233_MP5 (I1_p4_30 I1_I746_G29_0 XI1_I746_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I233_MP4 (XI1_I746_I233_p1 XI1_I746_I233_An I1_p4_30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I233_MP2 (VDD I1_I746_pn30 XI1_I746_I233_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I233_MP3 (XI1_I746_I233_p1 XI1_I746_I233_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I233_MP0 (VDD I1_I746_pn30 XI1_I746_I233_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I58_MP1 (VDD I1_b4_26 XI1_I746_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I58_MP5 (I1_I746_pn26 I1_b4_26 XI1_I746_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I58_MP4 (XI1_I746_I58_p1 XI1_I746_I58_An I1_I746_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I58_MP2 (VDD I1_p3_25 XI1_I746_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I58_MP3 (XI1_I746_I58_p1 XI1_I746_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I58_MP0 (VDD I1_p3_25 XI1_I746_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I59_MP1 (VDD I1_b4_27 XI1_I746_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I59_MP5 (I1_I746_pn27 I1_b4_27 XI1_I746_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I59_MP4 (XI1_I746_I59_p1 XI1_I746_I59_An I1_I746_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I59_MP2 (VDD I1_p3_26 XI1_I746_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I59_MP3 (XI1_I746_I59_p1 XI1_I746_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I59_MP0 (VDD I1_p3_26 XI1_I746_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I59_MP1 (VDD I1_b17_27 XI1_I1344_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I59_MP5 (I1_I1344_pn27 I1_b17_27 XI1_I1344_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I59_MP4 (XI1_I1344_I59_p1 XI1_I1344_I59_An I1_I1344_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I59_MP2 (VDD I1_p16_26 XI1_I1344_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I59_MP3 (XI1_I1344_I59_p1 XI1_I1344_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I59_MP0 (VDD I1_p16_26 XI1_I1344_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I223_MP1 (VDD I1_I1344_G19_0 XI1_I1344_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I223_MP5 (I1_p17_20 I1_I1344_G19_0 XI1_I1344_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I223_MP4 (XI1_I1344_I223_p1 XI1_I1344_I223_An I1_p17_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I223_MP2 (VDD I1_I1344_pn20 XI1_I1344_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I223_MP3 (XI1_I1344_I223_p1 XI1_I1344_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I223_MP0 (VDD I1_I1344_pn20 XI1_I1344_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I227_MP1 (VDD I1_I1298_G23_0 XI1_I1298_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I227_MP5 (I1_p16_24 I1_I1298_G23_0 XI1_I1298_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I227_MP4 (XI1_I1298_I227_p1 XI1_I1298_I227_An I1_p16_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I227_MP2 (VDD I1_I1298_pn24 XI1_I1298_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I227_MP3 (XI1_I1298_I227_p1 XI1_I1298_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I227_MP0 (VDD I1_I1298_pn24 XI1_I1298_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I226_MP1 (VDD I1_I1298_G22_0 XI1_I1298_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I226_MP5 (I1_p16_23 I1_I1298_G22_0 XI1_I1298_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I226_MP4 (XI1_I1298_I226_p1 XI1_I1298_I226_An I1_p16_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I226_MP2 (VDD I1_I1298_pn23 XI1_I1298_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I226_MP3 (XI1_I1298_I226_p1 XI1_I1298_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I226_MP0 (VDD I1_I1298_pn23 XI1_I1298_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I228_MP1 (VDD I1_I1298_G24_0 XI1_I1298_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I228_MP5 (I1_p16_25 I1_I1298_G24_0 XI1_I1298_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I228_MP4 (XI1_I1298_I228_p1 XI1_I1298_I228_An I1_p16_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I228_MP2 (VDD I1_I1298_pn25 XI1_I1298_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I228_MP3 (XI1_I1298_I228_p1 XI1_I1298_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I228_MP0 (VDD I1_I1298_pn25 XI1_I1298_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I54_MP1 (VDD I1_b16_22 XI1_I1298_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I54_MP5 (I1_I1298_pn22 I1_b16_22 XI1_I1298_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I54_MP4 (XI1_I1298_I54_p1 XI1_I1298_I54_An I1_I1298_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I54_MP2 (VDD I1_p15_21 XI1_I1298_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I54_MP3 (XI1_I1298_I54_p1 XI1_I1298_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I54_MP0 (VDD I1_p15_21 XI1_I1298_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I55_MP1 (VDD I1_b16_23 XI1_I1298_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I55_MP5 (I1_I1298_pn23 I1_b16_23 XI1_I1298_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I55_MP4 (XI1_I1298_I55_p1 XI1_I1298_I55_An I1_I1298_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I55_MP2 (VDD I1_p15_22 XI1_I1298_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I55_MP3 (XI1_I1298_I55_p1 XI1_I1298_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I55_MP0 (VDD I1_p15_22 XI1_I1298_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I224_MP1 (VDD I1_I1252_G20_0 XI1_I1252_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I224_MP5 (I1_p15_21 I1_I1252_G20_0 XI1_I1252_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I224_MP4 (XI1_I1252_I224_p1 XI1_I1252_I224_An I1_p15_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I224_MP2 (VDD I1_I1252_pn21 XI1_I1252_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I224_MP3 (XI1_I1252_I224_p1 XI1_I1252_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I224_MP0 (VDD I1_I1252_pn21 XI1_I1252_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I226_MP1 (VDD I1_I1252_G22_0 XI1_I1252_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I226_MP5 (I1_p15_23 I1_I1252_G22_0 XI1_I1252_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I226_MP4 (XI1_I1252_I226_p1 XI1_I1252_I226_An I1_p15_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I226_MP2 (VDD I1_I1252_pn23 XI1_I1252_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I226_MP3 (XI1_I1252_I226_p1 XI1_I1252_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I226_MP0 (VDD I1_I1252_pn23 XI1_I1252_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I225_MP1 (VDD I1_I1252_G21_0 XI1_I1252_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I225_MP5 (I1_p15_22 I1_I1252_G21_0 XI1_I1252_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I225_MP4 (XI1_I1252_I225_p1 XI1_I1252_I225_An I1_p15_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I225_MP2 (VDD I1_I1252_pn22 XI1_I1252_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I225_MP3 (XI1_I1252_I225_p1 XI1_I1252_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I225_MP0 (VDD I1_I1252_pn22 XI1_I1252_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I55_MP1 (VDD I1_b15_23 XI1_I1252_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I55_MP5 (I1_I1252_pn23 I1_b15_23 XI1_I1252_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I55_MP4 (XI1_I1252_I55_p1 XI1_I1252_I55_An I1_I1252_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I55_MP2 (VDD I1_p14_22 XI1_I1252_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I55_MP3 (XI1_I1252_I55_p1 XI1_I1252_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I55_MP0 (VDD I1_p14_22 XI1_I1252_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I55_MP1 (VDD I1_b14_23 XI1_I1206_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I55_MP5 (I1_I1206_pn23 I1_b14_23 XI1_I1206_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I55_MP4 (XI1_I1206_I55_p1 XI1_I1206_I55_An I1_I1206_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I55_MP2 (VDD I1_p13_22 XI1_I1206_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I55_MP3 (XI1_I1206_I55_p1 XI1_I1206_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I55_MP0 (VDD I1_p13_22 XI1_I1206_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I226_MP1 (VDD I1_I1206_G22_0 XI1_I1206_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I226_MP5 (I1_p14_23 I1_I1206_G22_0 XI1_I1206_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I226_MP4 (XI1_I1206_I226_p1 XI1_I1206_I226_An I1_p14_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I226_MP2 (VDD I1_I1206_pn23 XI1_I1206_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I226_MP3 (XI1_I1206_I226_p1 XI1_I1206_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I226_MP0 (VDD I1_I1206_pn23 XI1_I1206_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I56_MP1 (VDD I1_b14_24 XI1_I1206_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I56_MP5 (I1_I1206_pn24 I1_b14_24 XI1_I1206_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I56_MP4 (XI1_I1206_I56_p1 XI1_I1206_I56_An I1_I1206_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I56_MP2 (VDD I1_p13_23 XI1_I1206_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I56_MP3 (XI1_I1206_I56_p1 XI1_I1206_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I56_MP0 (VDD I1_p13_23 XI1_I1206_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I225_MP1 (VDD I1_I1206_G21_0 XI1_I1206_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I225_MP5 (I1_p14_22 I1_I1206_G21_0 XI1_I1206_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I225_MP4 (XI1_I1206_I225_p1 XI1_I1206_I225_An I1_p14_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I225_MP2 (VDD I1_I1206_pn22 XI1_I1206_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I225_MP3 (XI1_I1206_I225_p1 XI1_I1206_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I225_MP0 (VDD I1_I1206_pn22 XI1_I1206_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I57_MP1 (VDD I1_b14_25 XI1_I1206_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I57_MP5 (I1_I1206_pn25 I1_b14_25 XI1_I1206_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I57_MP4 (XI1_I1206_I57_p1 XI1_I1206_I57_An I1_I1206_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I57_MP2 (VDD I1_p13_24 XI1_I1206_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I57_MP3 (XI1_I1206_I57_p1 XI1_I1206_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I57_MP0 (VDD I1_p13_24 XI1_I1206_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I231_MP1 (VDD I1_I838_G27_0 XI1_I838_I231_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I231_MP5 (I1_p6_28 I1_I838_G27_0 XI1_I838_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I231_MP4 (XI1_I838_I231_p1 XI1_I838_I231_An I1_p6_28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I231_MP2 (VDD I1_I838_pn28 XI1_I838_I231_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I231_MP3 (XI1_I838_I231_p1 XI1_I838_I231_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I231_MP0 (VDD I1_I838_pn28 XI1_I838_I231_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I58_MP1 (VDD I1_b6_26 XI1_I838_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I58_MP5 (I1_I838_pn26 I1_b6_26 XI1_I838_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I58_MP4 (XI1_I838_I58_p1 XI1_I838_I58_An I1_I838_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I58_MP2 (VDD I1_p5_25 XI1_I838_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I58_MP3 (XI1_I838_I58_p1 XI1_I838_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I58_MP0 (VDD I1_p5_25 XI1_I838_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I54_MP1 (VDD I1_b6_22 XI1_I838_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I54_MP5 (I1_I838_pn22 I1_b6_22 XI1_I838_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I54_MP4 (XI1_I838_I54_p1 XI1_I838_I54_An I1_I838_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I54_MP2 (VDD I1_p5_21 XI1_I838_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I54_MP3 (XI1_I838_I54_p1 XI1_I838_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I54_MP0 (VDD I1_p5_21 XI1_I838_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I52_MP1 (VDD I1_b6_20 XI1_I838_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I52_MP5 (I1_I838_pn20 I1_b6_20 XI1_I838_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I52_MP4 (XI1_I838_I52_p1 XI1_I838_I52_An I1_I838_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I52_MP2 (VDD I1_p5_19 XI1_I838_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I52_MP3 (XI1_I838_I52_p1 XI1_I838_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I52_MP0 (VDD I1_p5_19 XI1_I838_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I50_MP1 (VDD I1_b6_18 XI1_I838_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I50_MP5 (I1_I838_pn18 I1_b6_18 XI1_I838_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I50_MP4 (XI1_I838_I50_p1 XI1_I838_I50_An I1_I838_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I50_MP2 (VDD I1_p5_17 XI1_I838_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I50_MP3 (XI1_I838_I50_p1 XI1_I838_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I50_MP0 (VDD I1_p5_17 XI1_I838_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I48_MP1 (VDD I1_b6_16 XI1_I838_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I48_MP5 (I1_I838_pn16 I1_b6_16 XI1_I838_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I48_MP4 (XI1_I838_I48_p1 XI1_I838_I48_An I1_I838_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I48_MP2 (VDD I1_p5_15 XI1_I838_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I48_MP3 (XI1_I838_I48_p1 XI1_I838_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I48_MP0 (VDD I1_p5_15 XI1_I838_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I49_MP1 (VDD I1_b6_17 XI1_I838_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I49_MP5 (I1_I838_pn17 I1_b6_17 XI1_I838_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I49_MP4 (XI1_I838_I49_p1 XI1_I838_I49_An I1_I838_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I49_MP2 (VDD I1_p5_16 XI1_I838_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I49_MP3 (XI1_I838_I49_p1 XI1_I838_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I49_MP0 (VDD I1_p5_16 XI1_I838_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I47_MP1 (VDD I1_b6_15 XI1_I838_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I47_MP5 (I1_I838_pn15 I1_b6_15 XI1_I838_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I47_MP4 (XI1_I838_I47_p1 XI1_I838_I47_An I1_I838_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I47_MP2 (VDD I1_p5_14 XI1_I838_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I47_MP3 (XI1_I838_I47_p1 XI1_I838_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I47_MP0 (VDD I1_p5_14 XI1_I838_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I45_MP1 (VDD I1_b6_13 XI1_I838_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I45_MP5 (I1_I838_pn13 I1_b6_13 XI1_I838_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I45_MP4 (XI1_I838_I45_p1 XI1_I838_I45_An I1_I838_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I45_MP2 (VDD I1_p5_12 XI1_I838_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I45_MP3 (XI1_I838_I45_p1 XI1_I838_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I45_MP0 (VDD I1_p5_12 XI1_I838_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I43_MP1 (VDD I1_b6_11 XI1_I838_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I43_MP5 (I1_I838_pn11 I1_b6_11 XI1_I838_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I43_MP4 (XI1_I838_I43_p1 XI1_I838_I43_An I1_I838_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I43_MP2 (VDD I1_p5_10 XI1_I838_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I43_MP3 (XI1_I838_I43_p1 XI1_I838_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I43_MP0 (VDD I1_p5_10 XI1_I838_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I222_MP1 (VDD I1_I792_G18_0 XI1_I792_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I222_MP5 (I1_p5_19 I1_I792_G18_0 XI1_I792_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I222_MP4 (XI1_I792_I222_p1 XI1_I792_I222_An I1_p5_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I222_MP2 (VDD I1_I792_pn19 XI1_I792_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I222_MP3 (XI1_I792_I222_p1 XI1_I792_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I222_MP0 (VDD I1_I792_pn19 XI1_I792_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I224_MP1 (VDD I1_I792_G20_0 XI1_I792_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I224_MP5 (I1_p5_21 I1_I792_G20_0 XI1_I792_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I224_MP4 (XI1_I792_I224_p1 XI1_I792_I224_An I1_p5_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I224_MP2 (VDD I1_I792_pn21 XI1_I792_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I224_MP3 (XI1_I792_I224_p1 XI1_I792_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I224_MP0 (VDD I1_I792_pn21 XI1_I792_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I52_MP1 (VDD I1_b5_20 XI1_I792_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I52_MP5 (I1_I792_pn20 I1_b5_20 XI1_I792_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I52_MP4 (XI1_I792_I52_p1 XI1_I792_I52_An I1_I792_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I52_MP2 (VDD I1_p4_19 XI1_I792_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I52_MP3 (XI1_I792_I52_p1 XI1_I792_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I52_MP0 (VDD I1_p4_19 XI1_I792_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I53_MP1 (VDD I1_b5_21 XI1_I792_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I53_MP5 (I1_I792_pn21 I1_b5_21 XI1_I792_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I53_MP4 (XI1_I792_I53_p1 XI1_I792_I53_An I1_I792_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I53_MP2 (VDD I1_p4_20 XI1_I792_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I53_MP3 (XI1_I792_I53_p1 XI1_I792_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I53_MP0 (VDD I1_p4_20 XI1_I792_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I54_MP1 (VDD I1_b5_22 XI1_I792_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I54_MP5 (I1_I792_pn22 I1_b5_22 XI1_I792_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I54_MP4 (XI1_I792_I54_p1 XI1_I792_I54_An I1_I792_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I54_MP2 (VDD I1_p4_21 XI1_I792_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I54_MP3 (XI1_I792_I54_p1 XI1_I792_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I54_MP0 (VDD I1_p4_21 XI1_I792_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I228_MP1 (VDD I1_I746_G24_0 XI1_I746_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I228_MP5 (I1_p4_25 I1_I746_G24_0 XI1_I746_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I228_MP4 (XI1_I746_I228_p1 XI1_I746_I228_An I1_p4_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I228_MP2 (VDD I1_I746_pn25 XI1_I746_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I228_MP3 (XI1_I746_I228_p1 XI1_I746_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I228_MP0 (VDD I1_I746_pn25 XI1_I746_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I232_MP1 (VDD I1_I746_G28_0 XI1_I746_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I232_MP5 (I1_p4_29 I1_I746_G28_0 XI1_I746_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I232_MP4 (XI1_I746_I232_p1 XI1_I746_I232_An I1_p4_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I232_MP2 (VDD I1_I746_pn29 XI1_I746_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I232_MP3 (XI1_I746_I232_p1 XI1_I746_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I232_MP0 (VDD I1_I746_pn29 XI1_I746_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I60_MP1 (VDD I1_b4_28 XI1_I746_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I60_MP5 (I1_I746_pn28 I1_b4_28 XI1_I746_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I60_MP4 (XI1_I746_I60_p1 XI1_I746_I60_An I1_I746_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I60_MP2 (VDD I1_p3_27 XI1_I746_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I60_MP3 (XI1_I746_I60_p1 XI1_I746_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I60_MP0 (VDD I1_p3_27 XI1_I746_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I58_MP1 (VDD I1_b17_26 XI1_I1344_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I58_MP5 (I1_I1344_pn26 I1_b17_26 XI1_I1344_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I58_MP4 (XI1_I1344_I58_p1 XI1_I1344_I58_An I1_I1344_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I58_MP2 (VDD I1_p16_25 XI1_I1344_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I58_MP3 (XI1_I1344_I58_p1 XI1_I1344_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I58_MP0 (VDD I1_p16_25 XI1_I1344_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I57_MP1 (VDD I1_b17_25 XI1_I1344_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I57_MP5 (I1_I1344_pn25 I1_b17_25 XI1_I1344_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I57_MP4 (XI1_I1344_I57_p1 XI1_I1344_I57_An I1_I1344_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I57_MP2 (VDD I1_p16_24 XI1_I1344_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I57_MP3 (XI1_I1344_I57_p1 XI1_I1344_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I57_MP0 (VDD I1_p16_24 XI1_I1344_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I56_MP1 (VDD I1_b17_24 XI1_I1344_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I56_MP5 (I1_I1344_pn24 I1_b17_24 XI1_I1344_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I56_MP4 (XI1_I1344_I56_p1 XI1_I1344_I56_An I1_I1344_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I56_MP2 (VDD I1_p16_23 XI1_I1344_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I56_MP3 (XI1_I1344_I56_p1 XI1_I1344_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I56_MP0 (VDD I1_p16_23 XI1_I1344_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I225_MP1 (VDD I1_I1344_G21_0 XI1_I1344_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I225_MP5 (I1_p17_22 I1_I1344_G21_0 XI1_I1344_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I225_MP4 (XI1_I1344_I225_p1 XI1_I1344_I225_An I1_p17_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I225_MP2 (VDD I1_I1344_pn22 XI1_I1344_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I225_MP3 (XI1_I1344_I225_p1 XI1_I1344_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I225_MP0 (VDD I1_I1344_pn22 XI1_I1344_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I55_MP1 (VDD I1_b17_23 XI1_I1344_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I55_MP5 (I1_I1344_pn23 I1_b17_23 XI1_I1344_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I55_MP4 (XI1_I1344_I55_p1 XI1_I1344_I55_An I1_I1344_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I55_MP2 (VDD I1_p16_22 XI1_I1344_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I55_MP3 (XI1_I1344_I55_p1 XI1_I1344_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I55_MP0 (VDD I1_p16_22 XI1_I1344_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I225_MP1 (VDD I1_I1298_G21_0 XI1_I1298_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I225_MP5 (I1_p16_22 I1_I1298_G21_0 XI1_I1298_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I225_MP4 (XI1_I1298_I225_p1 XI1_I1298_I225_An I1_p16_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I225_MP2 (VDD I1_I1298_pn22 XI1_I1298_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I225_MP3 (XI1_I1298_I225_p1 XI1_I1298_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I225_MP0 (VDD I1_I1298_pn22 XI1_I1298_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I53_MP1 (VDD I1_b16_21 XI1_I1298_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I53_MP5 (I1_I1298_pn21 I1_b16_21 XI1_I1298_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I53_MP4 (XI1_I1298_I53_p1 XI1_I1298_I53_An I1_I1298_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I53_MP2 (VDD I1_p15_20 XI1_I1298_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I53_MP3 (XI1_I1298_I53_p1 XI1_I1298_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I53_MP0 (VDD I1_p15_20 XI1_I1298_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I223_MP1 (VDD I1_I1252_G19_0 XI1_I1252_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I223_MP5 (I1_p15_20 I1_I1252_G19_0 XI1_I1252_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I223_MP4 (XI1_I1252_I223_p1 XI1_I1252_I223_An I1_p15_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I223_MP2 (VDD I1_I1252_pn20 XI1_I1252_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I223_MP3 (XI1_I1252_I223_p1 XI1_I1252_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I223_MP0 (VDD I1_I1252_pn20 XI1_I1252_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I54_MP1 (VDD I1_b15_22 XI1_I1252_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I54_MP5 (I1_I1252_pn22 I1_b15_22 XI1_I1252_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I54_MP4 (XI1_I1252_I54_p1 XI1_I1252_I54_An I1_I1252_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I54_MP2 (VDD I1_p14_21 XI1_I1252_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I54_MP3 (XI1_I1252_I54_p1 XI1_I1252_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I54_MP0 (VDD I1_p14_21 XI1_I1252_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I53_MP1 (VDD I1_b15_21 XI1_I1252_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I53_MP5 (I1_I1252_pn21 I1_b15_21 XI1_I1252_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I53_MP4 (XI1_I1252_I53_p1 XI1_I1252_I53_An I1_I1252_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I53_MP2 (VDD I1_p14_20 XI1_I1252_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I53_MP3 (XI1_I1252_I53_p1 XI1_I1252_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I53_MP0 (VDD I1_p14_20 XI1_I1252_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I53_MP1 (VDD I1_b14_21 XI1_I1206_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I53_MP5 (I1_I1206_pn21 I1_b14_21 XI1_I1206_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I53_MP4 (XI1_I1206_I53_p1 XI1_I1206_I53_An I1_I1206_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I53_MP2 (VDD I1_p13_20 XI1_I1206_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I53_MP3 (XI1_I1206_I53_p1 XI1_I1206_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I53_MP0 (VDD I1_p13_20 XI1_I1206_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I224_MP1 (VDD I1_I1206_G20_0 XI1_I1206_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I224_MP5 (I1_p14_21 I1_I1206_G20_0 XI1_I1206_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I224_MP4 (XI1_I1206_I224_p1 XI1_I1206_I224_An I1_p14_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I224_MP2 (VDD I1_I1206_pn21 XI1_I1206_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I224_MP3 (XI1_I1206_I224_p1 XI1_I1206_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I224_MP0 (VDD I1_I1206_pn21 XI1_I1206_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I54_MP1 (VDD I1_b14_22 XI1_I1206_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I54_MP5 (I1_I1206_pn22 I1_b14_22 XI1_I1206_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I54_MP4 (XI1_I1206_I54_p1 XI1_I1206_I54_An I1_I1206_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I54_MP2 (VDD I1_p13_21 XI1_I1206_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I54_MP3 (XI1_I1206_I54_p1 XI1_I1206_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I54_MP0 (VDD I1_p13_21 XI1_I1206_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I223_MP1 (VDD I1_I1206_G19_0 XI1_I1206_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I223_MP5 (I1_p14_20 I1_I1206_G19_0 XI1_I1206_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I223_MP4 (XI1_I1206_I223_p1 XI1_I1206_I223_An I1_p14_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I223_MP2 (VDD I1_I1206_pn20 XI1_I1206_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I223_MP3 (XI1_I1206_I223_p1 XI1_I1206_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I223_MP0 (VDD I1_I1206_pn20 XI1_I1206_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I229_MP1 (VDD I1_I838_G25_0 XI1_I838_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I229_MP5 (I1_p6_26 I1_I838_G25_0 XI1_I838_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I229_MP4 (XI1_I838_I229_p1 XI1_I838_I229_An I1_p6_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I229_MP2 (VDD I1_I838_pn26 XI1_I838_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I229_MP3 (XI1_I838_I229_p1 XI1_I838_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I229_MP0 (VDD I1_I838_pn26 XI1_I838_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I51_MP1 (VDD I1_b6_19 XI1_I838_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I51_MP5 (I1_I838_pn19 I1_b6_19 XI1_I838_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I51_MP4 (XI1_I838_I51_p1 XI1_I838_I51_An I1_I838_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I51_MP2 (VDD I1_p5_18 XI1_I838_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I51_MP3 (XI1_I838_I51_p1 XI1_I838_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I51_MP0 (VDD I1_p5_18 XI1_I838_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I46_MP1 (VDD I1_b6_14 XI1_I838_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I46_MP5 (I1_I838_pn14 I1_b6_14 XI1_I838_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I46_MP4 (XI1_I838_I46_p1 XI1_I838_I46_An I1_I838_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I46_MP2 (VDD I1_p5_13 XI1_I838_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I46_MP3 (XI1_I838_I46_p1 XI1_I838_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I46_MP0 (VDD I1_p5_13 XI1_I838_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I44_MP1 (VDD I1_b6_12 XI1_I838_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I44_MP5 (I1_I838_pn12 I1_b6_12 XI1_I838_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I44_MP4 (XI1_I838_I44_p1 XI1_I838_I44_An I1_I838_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I44_MP2 (VDD I1_p5_11 XI1_I838_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I44_MP3 (XI1_I838_I44_p1 XI1_I838_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I44_MP0 (VDD I1_p5_11 XI1_I838_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I211_MP1 (VDD I1_I838_G7_0 XI1_I838_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I211_MP5 (I1_p6_8 I1_I838_G7_0 XI1_I838_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I211_MP4 (XI1_I838_I211_p1 XI1_I838_I211_An I1_p6_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I211_MP2 (VDD I1_I838_pn8 XI1_I838_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I211_MP3 (XI1_I838_I211_p1 XI1_I838_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I211_MP0 (VDD I1_I838_pn8 XI1_I838_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I221_MP1 (VDD I1_I792_G17_0 XI1_I792_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I221_MP5 (I1_p5_18 I1_I792_G17_0 XI1_I792_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I221_MP4 (XI1_I792_I221_p1 XI1_I792_I221_An I1_p5_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I221_MP2 (VDD I1_I792_pn18 XI1_I792_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I221_MP3 (XI1_I792_I221_p1 XI1_I792_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I221_MP0 (VDD I1_I792_pn18 XI1_I792_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I51_MP1 (VDD I1_b5_19 XI1_I792_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I51_MP5 (I1_I792_pn19 I1_b5_19 XI1_I792_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I51_MP4 (XI1_I792_I51_p1 XI1_I792_I51_An I1_I792_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I51_MP2 (VDD I1_p4_18 XI1_I792_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I51_MP3 (XI1_I792_I51_p1 XI1_I792_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I51_MP0 (VDD I1_p4_18 XI1_I792_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I222_MP1 (VDD I1_I746_G18_0 XI1_I746_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I222_MP5 (I1_p4_19 I1_I746_G18_0 XI1_I746_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I222_MP4 (XI1_I746_I222_p1 XI1_I746_I222_An I1_p4_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I222_MP2 (VDD I1_I746_pn19 XI1_I746_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I222_MP3 (XI1_I746_I222_p1 XI1_I746_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I222_MP0 (VDD I1_I746_pn19 XI1_I746_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I224_MP1 (VDD I1_I746_G20_0 XI1_I746_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I224_MP5 (I1_p4_21 I1_I746_G20_0 XI1_I746_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I224_MP4 (XI1_I746_I224_p1 XI1_I746_I224_An I1_p4_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I224_MP2 (VDD I1_I746_pn21 XI1_I746_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I224_MP3 (XI1_I746_I224_p1 XI1_I746_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I224_MP0 (VDD I1_I746_pn21 XI1_I746_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I227_MP1 (VDD I1_I746_G23_0 XI1_I746_I227_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I227_MP5 (I1_p4_24 I1_I746_G23_0 XI1_I746_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I227_MP4 (XI1_I746_I227_p1 XI1_I746_I227_An I1_p4_24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I227_MP2 (VDD I1_I746_pn24 XI1_I746_I227_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I227_MP3 (XI1_I746_I227_p1 XI1_I746_I227_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I227_MP0 (VDD I1_I746_pn24 XI1_I746_I227_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I57_MP1 (VDD I1_b4_25 XI1_I746_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I57_MP5 (I1_I746_pn25 I1_b4_25 XI1_I746_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I57_MP4 (XI1_I746_I57_p1 XI1_I746_I57_An I1_I746_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I57_MP2 (VDD I1_p3_24 XI1_I746_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I57_MP3 (XI1_I746_I57_p1 XI1_I746_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I57_MP0 (VDD I1_p3_24 XI1_I746_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I61_MP1 (VDD I1_b4_29 XI1_I746_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I61_MP5 (I1_I746_pn29 I1_b4_29 XI1_I746_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I61_MP4 (XI1_I746_I61_p1 XI1_I746_I61_An I1_I746_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I61_MP2 (VDD I1_p3_28 XI1_I746_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I61_MP3 (XI1_I746_I61_p1 XI1_I746_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I61_MP0 (VDD I1_p3_28 XI1_I746_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I229_MP1 (VDD I1_I1344_G25_0 XI1_I1344_I229_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I229_MP5 (I1_p17_26 I1_I1344_G25_0 XI1_I1344_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I229_MP4 (XI1_I1344_I229_p1 XI1_I1344_I229_An I1_p17_26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I229_MP2 (VDD I1_I1344_pn26 XI1_I1344_I229_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I229_MP3 (XI1_I1344_I229_p1 XI1_I1344_I229_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I229_MP0 (VDD I1_I1344_pn26 XI1_I1344_I229_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I54_MP1 (VDD I1_b17_22 XI1_I1344_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I54_MP5 (I1_I1344_pn22 I1_b17_22 XI1_I1344_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I54_MP4 (XI1_I1344_I54_p1 XI1_I1344_I54_An I1_I1344_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I54_MP2 (VDD I1_p16_21 XI1_I1344_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I54_MP3 (XI1_I1344_I54_p1 XI1_I1344_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I54_MP0 (VDD I1_p16_21 XI1_I1344_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I53_MP1 (VDD I1_b17_21 XI1_I1344_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I53_MP5 (I1_I1344_pn21 I1_b17_21 XI1_I1344_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I53_MP4 (XI1_I1344_I53_p1 XI1_I1344_I53_An I1_I1344_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I53_MP2 (VDD I1_p16_20 XI1_I1344_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I53_MP3 (XI1_I1344_I53_p1 XI1_I1344_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I53_MP0 (VDD I1_p16_20 XI1_I1344_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I49_MP1 (VDD I1_b17_17 XI1_I1344_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I49_MP5 (I1_I1344_pn17 I1_b17_17 XI1_I1344_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I49_MP4 (XI1_I1344_I49_p1 XI1_I1344_I49_An I1_I1344_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I49_MP2 (VDD I1_p16_16 XI1_I1344_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I49_MP3 (XI1_I1344_I49_p1 XI1_I1344_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I49_MP0 (VDD I1_p16_16 XI1_I1344_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I48_MP1 (VDD I1_b17_16 XI1_I1344_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I48_MP5 (I1_I1344_pn16 I1_b17_16 XI1_I1344_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I48_MP4 (XI1_I1344_I48_p1 XI1_I1344_I48_An I1_I1344_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I48_MP2 (VDD I1_p16_15 XI1_I1344_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I48_MP3 (XI1_I1344_I48_p1 XI1_I1344_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I48_MP0 (VDD I1_p16_15 XI1_I1344_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I223_MP1 (VDD I1_I1298_G19_0 XI1_I1298_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I223_MP5 (I1_p16_20 I1_I1298_G19_0 XI1_I1298_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I223_MP4 (XI1_I1298_I223_p1 XI1_I1298_I223_An I1_p16_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I223_MP2 (VDD I1_I1298_pn20 XI1_I1298_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I223_MP3 (XI1_I1298_I223_p1 XI1_I1298_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I223_MP0 (VDD I1_I1298_pn20 XI1_I1298_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I224_MP1 (VDD I1_I1298_G20_0 XI1_I1298_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I224_MP5 (I1_p16_21 I1_I1298_G20_0 XI1_I1298_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I224_MP4 (XI1_I1298_I224_p1 XI1_I1298_I224_An I1_p16_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I224_MP2 (VDD I1_I1298_pn21 XI1_I1298_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I224_MP3 (XI1_I1298_I224_p1 XI1_I1298_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I224_MP0 (VDD I1_I1298_pn21 XI1_I1298_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I52_MP1 (VDD I1_b16_20 XI1_I1298_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I52_MP5 (I1_I1298_pn20 I1_b16_20 XI1_I1298_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I52_MP4 (XI1_I1298_I52_p1 XI1_I1298_I52_An I1_I1298_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I52_MP2 (VDD I1_p15_19 XI1_I1298_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I52_MP3 (XI1_I1298_I52_p1 XI1_I1298_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I52_MP0 (VDD I1_p15_19 XI1_I1298_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I51_MP1 (VDD I1_b16_19 XI1_I1298_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I51_MP5 (I1_I1298_pn19 I1_b16_19 XI1_I1298_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I51_MP4 (XI1_I1298_I51_p1 XI1_I1298_I51_An I1_I1298_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I51_MP2 (VDD I1_p15_18 XI1_I1298_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I51_MP3 (XI1_I1298_I51_p1 XI1_I1298_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I51_MP0 (VDD I1_p15_18 XI1_I1298_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I222_MP1 (VDD I1_I1252_G18_0 XI1_I1252_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I222_MP5 (I1_p15_19 I1_I1252_G18_0 XI1_I1252_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I222_MP4 (XI1_I1252_I222_p1 XI1_I1252_I222_An I1_p15_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I222_MP2 (VDD I1_I1252_pn19 XI1_I1252_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I222_MP3 (XI1_I1252_I222_p1 XI1_I1252_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I222_MP0 (VDD I1_I1252_pn19 XI1_I1252_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I52_MP1 (VDD I1_b15_20 XI1_I1252_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I52_MP5 (I1_I1252_pn20 I1_b15_20 XI1_I1252_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I52_MP4 (XI1_I1252_I52_p1 XI1_I1252_I52_An I1_I1252_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I52_MP2 (VDD I1_p14_19 XI1_I1252_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I52_MP3 (XI1_I1252_I52_p1 XI1_I1252_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I52_MP0 (VDD I1_p14_19 XI1_I1252_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I52_MP1 (VDD I1_b14_20 XI1_I1206_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I52_MP5 (I1_I1206_pn20 I1_b14_20 XI1_I1206_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I52_MP4 (XI1_I1206_I52_p1 XI1_I1206_I52_An I1_I1206_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I52_MP2 (VDD I1_p13_19 XI1_I1206_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I52_MP3 (XI1_I1206_I52_p1 XI1_I1206_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I52_MP0 (VDD I1_p13_19 XI1_I1206_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I232_MP1 (VDD I1_I838_G28_0 XI1_I838_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I232_MP5 (I1_p6_29 I1_I838_G28_0 XI1_I838_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I232_MP4 (XI1_I838_I232_p1 XI1_I838_I232_An I1_p6_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I232_MP2 (VDD I1_I838_pn29 XI1_I838_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I232_MP3 (XI1_I838_I232_p1 XI1_I838_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I232_MP0 (VDD I1_I838_pn29 XI1_I838_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I59_MP1 (VDD I1_b7_27 XI1_I884_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I59_MP5 (I1_I884_pn27 I1_b7_27 XI1_I884_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I59_MP4 (XI1_I884_I59_p1 XI1_I884_I59_An I1_I884_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I59_MP2 (VDD I1_p6_26 XI1_I884_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I59_MP3 (XI1_I884_I59_p1 XI1_I884_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I59_MP0 (VDD I1_p6_26 XI1_I884_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I230_MP1 (VDD I1_I838_G26_0 XI1_I838_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I230_MP5 (I1_p6_27 I1_I838_G26_0 XI1_I838_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I230_MP4 (XI1_I838_I230_p1 XI1_I838_I230_An I1_p6_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I230_MP2 (VDD I1_I838_pn27 XI1_I838_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I230_MP3 (XI1_I838_I230_p1 XI1_I838_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I230_MP0 (VDD I1_I838_pn27 XI1_I838_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I57_MP1 (VDD I1_b7_25 XI1_I884_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I57_MP5 (I1_I884_pn25 I1_b7_25 XI1_I884_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I57_MP4 (XI1_I884_I57_p1 XI1_I884_I57_An I1_I884_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I57_MP2 (VDD I1_p6_24 XI1_I884_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I57_MP3 (XI1_I884_I57_p1 XI1_I884_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I57_MP0 (VDD I1_p6_24 XI1_I884_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I234_MP1 (VDD I1_c6_m XI1_I838_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I234_MP5 (I1_p6_31 I1_c6_m XI1_I838_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I234_MP4 (XI1_I838_I234_p1 XI1_I838_I234_An I1_p6_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I234_MP2 (VDD I1_I838_pn31 XI1_I838_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I234_MP3 (XI1_I838_I234_p1 XI1_I838_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I234_MP0 (VDD I1_I838_pn31 XI1_I838_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I228_MP1 (VDD I1_I838_G24_0 XI1_I838_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I228_MP5 (I1_p6_25 I1_I838_G24_0 XI1_I838_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I228_MP4 (XI1_I838_I228_p1 XI1_I838_I228_An I1_p6_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I228_MP2 (VDD I1_I838_pn25 XI1_I838_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I228_MP3 (XI1_I838_I228_p1 XI1_I838_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I228_MP0 (VDD I1_I838_pn25 XI1_I838_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I226_MP1 (VDD I1_I838_G22_0 XI1_I838_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I226_MP5 (I1_p6_23 I1_I838_G22_0 XI1_I838_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I226_MP4 (XI1_I838_I226_p1 XI1_I838_I226_An I1_p6_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I226_MP2 (VDD I1_I838_pn23 XI1_I838_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I226_MP3 (XI1_I838_I226_p1 XI1_I838_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I226_MP0 (VDD I1_I838_pn23 XI1_I838_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I42_MP1 (VDD I1_b6_10 XI1_I838_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I42_MP5 (I1_I838_pn10 I1_b6_10 XI1_I838_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I42_MP4 (XI1_I838_I42_p1 XI1_I838_I42_An I1_I838_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I42_MP2 (VDD I1_p5_9 XI1_I838_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I42_MP3 (XI1_I838_I42_p1 XI1_I838_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I42_MP0 (VDD I1_p5_9 XI1_I838_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I41_MP1 (VDD I1_b6_9 XI1_I838_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I41_MP5 (I1_I838_pn9 I1_b6_9 XI1_I838_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I41_MP4 (XI1_I838_I41_p1 XI1_I838_I41_An I1_I838_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I41_MP2 (VDD I1_p5_8 XI1_I838_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I41_MP3 (XI1_I838_I41_p1 XI1_I838_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I41_MP0 (VDD I1_p5_8 XI1_I838_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I40_MP1 (VDD I1_b6_8 XI1_I838_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I40_MP5 (I1_I838_pn8 I1_b6_8 XI1_I838_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I40_MP4 (XI1_I838_I40_p1 XI1_I838_I40_An I1_I838_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I40_MP2 (VDD I1_p5_7 XI1_I838_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I40_MP3 (XI1_I838_I40_p1 XI1_I838_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I40_MP0 (VDD I1_p5_7 XI1_I838_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I211_MP1 (VDD I1_I792_G7_0 XI1_I792_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I211_MP5 (I1_p5_8 I1_I792_G7_0 XI1_I792_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I211_MP4 (XI1_I792_I211_p1 XI1_I792_I211_An I1_p5_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I211_MP2 (VDD I1_I792_pn8 XI1_I792_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I211_MP3 (XI1_I792_I211_p1 XI1_I792_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I211_MP0 (VDD I1_I792_pn8 XI1_I792_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I220_MP1 (VDD I1_I792_G16_0 XI1_I792_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I220_MP5 (I1_p5_17 I1_I792_G16_0 XI1_I792_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I220_MP4 (XI1_I792_I220_p1 XI1_I792_I220_An I1_p5_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I220_MP2 (VDD I1_I792_pn17 XI1_I792_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I220_MP3 (XI1_I792_I220_p1 XI1_I792_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I220_MP0 (VDD I1_I792_pn17 XI1_I792_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I47_MP1 (VDD I1_b5_15 XI1_I792_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I47_MP5 (I1_I792_pn15 I1_b5_15 XI1_I792_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I47_MP4 (XI1_I792_I47_p1 XI1_I792_I47_An I1_I792_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I47_MP2 (VDD I1_p4_14 XI1_I792_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I47_MP3 (XI1_I792_I47_p1 XI1_I792_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I47_MP0 (VDD I1_p4_14 XI1_I792_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I48_MP1 (VDD I1_b5_16 XI1_I792_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I48_MP5 (I1_I792_pn16 I1_b5_16 XI1_I792_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I48_MP4 (XI1_I792_I48_p1 XI1_I792_I48_An I1_I792_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I48_MP2 (VDD I1_p4_15 XI1_I792_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I48_MP3 (XI1_I792_I48_p1 XI1_I792_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I48_MP0 (VDD I1_p4_15 XI1_I792_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I49_MP1 (VDD I1_b5_17 XI1_I792_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I49_MP5 (I1_I792_pn17 I1_b5_17 XI1_I792_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I49_MP4 (XI1_I792_I49_p1 XI1_I792_I49_An I1_I792_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I49_MP2 (VDD I1_p4_16 XI1_I792_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I49_MP3 (XI1_I792_I49_p1 XI1_I792_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I49_MP0 (VDD I1_p4_16 XI1_I792_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I50_MP1 (VDD I1_b5_18 XI1_I792_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I50_MP5 (I1_I792_pn18 I1_b5_18 XI1_I792_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I50_MP4 (XI1_I792_I50_p1 XI1_I792_I50_An I1_I792_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I50_MP2 (VDD I1_p4_17 XI1_I792_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I50_MP3 (XI1_I792_I50_p1 XI1_I792_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I50_MP0 (VDD I1_p4_17 XI1_I792_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I234_MP1 (VDD I1_c17_m XI1_I1344_I234_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I234_MP5 (I1_p17_31 I1_c17_m XI1_I1344_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I234_MP4 (XI1_I1344_I234_p1 XI1_I1344_I234_An I1_p17_31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I234_MP2 (VDD I1_I1344_pn31 XI1_I1344_I234_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I234_MP3 (XI1_I1344_I234_p1 XI1_I1344_I234_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I234_MP0 (VDD I1_I1344_pn31 XI1_I1344_I234_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I52_MP1 (VDD I1_b17_20 XI1_I1344_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I52_MP5 (I1_I1344_pn20 I1_b17_20 XI1_I1344_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I52_MP4 (XI1_I1344_I52_p1 XI1_I1344_I52_An I1_I1344_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I52_MP2 (VDD I1_p16_19 XI1_I1344_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I52_MP3 (XI1_I1344_I52_p1 XI1_I1344_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I52_MP0 (VDD I1_p16_19 XI1_I1344_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I50_MP1 (VDD I1_b17_18 XI1_I1344_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I50_MP5 (I1_I1344_pn18 I1_b17_18 XI1_I1344_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I50_MP4 (XI1_I1344_I50_p1 XI1_I1344_I50_An I1_I1344_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I50_MP2 (VDD I1_p16_17 XI1_I1344_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I50_MP3 (XI1_I1344_I50_p1 XI1_I1344_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I50_MP0 (VDD I1_p16_17 XI1_I1344_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I221_MP1 (VDD I1_I1344_G17_0 XI1_I1344_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I221_MP5 (I1_p17_18 I1_I1344_G17_0 XI1_I1344_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I221_MP4 (XI1_I1344_I221_p1 XI1_I1344_I221_An I1_p17_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I221_MP2 (VDD I1_I1344_pn18 XI1_I1344_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I221_MP3 (XI1_I1344_I221_p1 XI1_I1344_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I221_MP0 (VDD I1_I1344_pn18 XI1_I1344_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I47_MP1 (VDD I1_b17_15 XI1_I1344_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I47_MP5 (I1_I1344_pn15 I1_b17_15 XI1_I1344_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I47_MP4 (XI1_I1344_I47_p1 XI1_I1344_I47_An I1_I1344_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I47_MP2 (VDD I1_p16_14 XI1_I1344_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I47_MP3 (XI1_I1344_I47_p1 XI1_I1344_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I47_MP0 (VDD I1_p16_14 XI1_I1344_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I222_MP1 (VDD I1_I1298_G18_0 XI1_I1298_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I222_MP5 (I1_p16_19 I1_I1298_G18_0 XI1_I1298_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I222_MP4 (XI1_I1298_I222_p1 XI1_I1298_I222_An I1_p16_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I222_MP2 (VDD I1_I1298_pn19 XI1_I1298_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I222_MP3 (XI1_I1298_I222_p1 XI1_I1298_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I222_MP0 (VDD I1_I1298_pn19 XI1_I1298_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I220_MP1 (VDD I1_I1298_G16_0 XI1_I1298_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I220_MP5 (I1_p16_17 I1_I1298_G16_0 XI1_I1298_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I220_MP4 (XI1_I1298_I220_p1 XI1_I1298_I220_An I1_p16_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I220_MP2 (VDD I1_I1298_pn17 XI1_I1298_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I220_MP3 (XI1_I1298_I220_p1 XI1_I1298_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I220_MP0 (VDD I1_I1298_pn17 XI1_I1298_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I49_MP1 (VDD I1_b16_17 XI1_I1298_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I49_MP5 (I1_I1298_pn17 I1_b16_17 XI1_I1298_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I49_MP4 (XI1_I1298_I49_p1 XI1_I1298_I49_An I1_I1298_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I49_MP2 (VDD I1_p15_16 XI1_I1298_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I49_MP3 (XI1_I1298_I49_p1 XI1_I1298_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I49_MP0 (VDD I1_p15_16 XI1_I1298_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I48_MP1 (VDD I1_b16_16 XI1_I1298_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I48_MP5 (I1_I1298_pn16 I1_b16_16 XI1_I1298_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I48_MP4 (XI1_I1298_I48_p1 XI1_I1298_I48_An I1_I1298_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I48_MP2 (VDD I1_p15_15 XI1_I1298_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I48_MP3 (XI1_I1298_I48_p1 XI1_I1298_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I48_MP0 (VDD I1_p15_15 XI1_I1298_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I50_MP1 (VDD I1_b16_18 XI1_I1298_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I50_MP5 (I1_I1298_pn18 I1_b16_18 XI1_I1298_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I50_MP4 (XI1_I1298_I50_p1 XI1_I1298_I50_An I1_I1298_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I50_MP2 (VDD I1_p15_17 XI1_I1298_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I50_MP3 (XI1_I1298_I50_p1 XI1_I1298_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I50_MP0 (VDD I1_p15_17 XI1_I1298_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I220_MP1 (VDD I1_I1252_G16_0 XI1_I1252_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I220_MP5 (I1_p15_17 I1_I1252_G16_0 XI1_I1252_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I220_MP4 (XI1_I1252_I220_p1 XI1_I1252_I220_An I1_p15_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I220_MP2 (VDD I1_I1252_pn17 XI1_I1252_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I220_MP3 (XI1_I1252_I220_p1 XI1_I1252_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I220_MP0 (VDD I1_I1252_pn17 XI1_I1252_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I221_MP1 (VDD I1_I1252_G17_0 XI1_I1252_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I221_MP5 (I1_p15_18 I1_I1252_G17_0 XI1_I1252_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I221_MP4 (XI1_I1252_I221_p1 XI1_I1252_I221_An I1_p15_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I221_MP2 (VDD I1_I1252_pn18 XI1_I1252_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I221_MP3 (XI1_I1252_I221_p1 XI1_I1252_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I221_MP0 (VDD I1_I1252_pn18 XI1_I1252_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I51_MP1 (VDD I1_b15_19 XI1_I1252_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I51_MP5 (I1_I1252_pn19 I1_b15_19 XI1_I1252_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I51_MP4 (XI1_I1252_I51_p1 XI1_I1252_I51_An I1_I1252_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I51_MP2 (VDD I1_p14_18 XI1_I1252_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I51_MP3 (XI1_I1252_I51_p1 XI1_I1252_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I51_MP0 (VDD I1_p14_18 XI1_I1252_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I50_MP1 (VDD I1_b15_18 XI1_I1252_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I50_MP5 (I1_I1252_pn18 I1_b15_18 XI1_I1252_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I50_MP4 (XI1_I1252_I50_p1 XI1_I1252_I50_An I1_I1252_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I50_MP2 (VDD I1_p14_17 XI1_I1252_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I50_MP3 (XI1_I1252_I50_p1 XI1_I1252_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I50_MP0 (VDD I1_p14_17 XI1_I1252_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I50_MP1 (VDD I1_b14_18 XI1_I1206_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I50_MP5 (I1_I1206_pn18 I1_b14_18 XI1_I1206_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I50_MP4 (XI1_I1206_I50_p1 XI1_I1206_I50_An I1_I1206_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I50_MP2 (VDD I1_p13_17 XI1_I1206_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I50_MP3 (XI1_I1206_I50_p1 XI1_I1206_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I50_MP0 (VDD I1_p13_17 XI1_I1206_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I51_MP1 (VDD I1_b14_19 XI1_I1206_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I51_MP5 (I1_I1206_pn19 I1_b14_19 XI1_I1206_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I51_MP4 (XI1_I1206_I51_p1 XI1_I1206_I51_An I1_I1206_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I51_MP2 (VDD I1_p13_18 XI1_I1206_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I51_MP3 (XI1_I1206_I51_p1 XI1_I1206_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I51_MP0 (VDD I1_p13_18 XI1_I1206_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I222_MP1 (VDD I1_I1206_G18_0 XI1_I1206_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I222_MP5 (I1_p14_19 I1_I1206_G18_0 XI1_I1206_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I222_MP4 (XI1_I1206_I222_p1 XI1_I1206_I222_An I1_p14_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I222_MP2 (VDD I1_I1206_pn19 XI1_I1206_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I222_MP3 (XI1_I1206_I222_p1 XI1_I1206_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I222_MP0 (VDD I1_I1206_pn19 XI1_I1206_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I61_MP1 (VDD I1_b7_29 XI1_I884_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I61_MP5 (I1_I884_pn29 I1_b7_29 XI1_I884_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I61_MP4 (XI1_I884_I61_p1 XI1_I884_I61_An I1_I884_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I61_MP2 (VDD I1_p6_28 XI1_I884_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I61_MP3 (XI1_I884_I61_p1 XI1_I884_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I61_MP0 (VDD I1_p6_28 XI1_I884_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I55_MP1 (VDD I1_b7_23 XI1_I884_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I55_MP5 (I1_I884_pn23 I1_b7_23 XI1_I884_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I55_MP4 (XI1_I884_I55_p1 XI1_I884_I55_An I1_I884_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I55_MP2 (VDD I1_p6_22 XI1_I884_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I55_MP3 (XI1_I884_I55_p1 XI1_I884_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I55_MP0 (VDD I1_p6_22 XI1_I884_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I224_MP1 (VDD I1_I838_G20_0 XI1_I838_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I224_MP5 (I1_p6_21 I1_I838_G20_0 XI1_I838_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I224_MP4 (XI1_I838_I224_p1 XI1_I838_I224_An I1_p6_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I224_MP2 (VDD I1_I838_pn21 XI1_I838_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I224_MP3 (XI1_I838_I224_p1 XI1_I838_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I224_MP0 (VDD I1_I838_pn21 XI1_I838_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I222_MP1 (VDD I1_I838_G18_0 XI1_I838_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I222_MP5 (I1_p6_19 I1_I838_G18_0 XI1_I838_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I222_MP4 (XI1_I838_I222_p1 XI1_I838_I222_An I1_p6_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I222_MP2 (VDD I1_I838_pn19 XI1_I838_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I222_MP3 (XI1_I838_I222_p1 XI1_I838_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I222_MP0 (VDD I1_I838_pn19 XI1_I838_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I210_MP1 (VDD I1_I838_G6_0 XI1_I838_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I210_MP5 (I1_p6_7 I1_I838_G6_0 XI1_I838_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I210_MP4 (XI1_I838_I210_p1 XI1_I838_I210_An I1_p6_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I210_MP2 (VDD I1_I838_pn7 XI1_I838_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I210_MP3 (XI1_I838_I210_p1 XI1_I838_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I210_MP0 (VDD I1_I838_pn7 XI1_I838_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I209_MP1 (VDD I1_I838_G5_0 XI1_I838_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I209_MP5 (I1_p6_6 I1_I838_G5_0 XI1_I838_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I209_MP4 (XI1_I838_I209_p1 XI1_I838_I209_An I1_p6_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I209_MP2 (VDD I1_I838_pn6 XI1_I838_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I209_MP3 (XI1_I838_I209_p1 XI1_I838_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I209_MP0 (VDD I1_I838_pn6 XI1_I838_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I39_MP1 (VDD I1_b6_7 XI1_I838_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I39_MP5 (I1_I838_pn7 I1_b6_7 XI1_I838_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I39_MP4 (XI1_I838_I39_p1 XI1_I838_I39_An I1_I838_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I39_MP2 (VDD I1_p5_6 XI1_I838_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I39_MP3 (XI1_I838_I39_p1 XI1_I838_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I39_MP0 (VDD I1_p5_6 XI1_I838_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I209_MP1 (VDD I1_I792_G5_0 XI1_I792_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I209_MP5 (I1_p5_6 I1_I792_G5_0 XI1_I792_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I209_MP4 (XI1_I792_I209_p1 XI1_I792_I209_An I1_p5_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I209_MP2 (VDD I1_I792_pn6 XI1_I792_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I209_MP3 (XI1_I792_I209_p1 XI1_I792_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I209_MP0 (VDD I1_I792_pn6 XI1_I792_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I210_MP1 (VDD I1_I792_G6_0 XI1_I792_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I210_MP5 (I1_p5_7 I1_I792_G6_0 XI1_I792_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I210_MP4 (XI1_I792_I210_p1 XI1_I792_I210_An I1_p5_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I210_MP2 (VDD I1_I792_pn7 XI1_I792_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I210_MP3 (XI1_I792_I210_p1 XI1_I792_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I210_MP0 (VDD I1_I792_pn7 XI1_I792_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I220_MP1 (VDD I1_I746_G16_0 XI1_I746_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I220_MP5 (I1_p4_17 I1_I746_G16_0 XI1_I746_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I220_MP4 (XI1_I746_I220_p1 XI1_I746_I220_An I1_p4_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I220_MP2 (VDD I1_I746_pn17 XI1_I746_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I220_MP3 (XI1_I746_I220_p1 XI1_I746_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I220_MP0 (VDD I1_I746_pn17 XI1_I746_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I221_MP1 (VDD I1_I746_G17_0 XI1_I746_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I221_MP5 (I1_p4_18 I1_I746_G17_0 XI1_I746_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I221_MP4 (XI1_I746_I221_p1 XI1_I746_I221_An I1_p4_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I221_MP2 (VDD I1_I746_pn18 XI1_I746_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I221_MP3 (XI1_I746_I221_p1 XI1_I746_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I221_MP0 (VDD I1_I746_pn18 XI1_I746_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I225_MP1 (VDD I1_I746_G21_0 XI1_I746_I225_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I225_MP5 (I1_p4_22 I1_I746_G21_0 XI1_I746_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I225_MP4 (XI1_I746_I225_p1 XI1_I746_I225_An I1_p4_22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I225_MP2 (VDD I1_I746_pn22 XI1_I746_I225_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I225_MP3 (XI1_I746_I225_p1 XI1_I746_I225_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I225_MP0 (VDD I1_I746_pn22 XI1_I746_I225_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I56_MP1 (VDD I1_b4_24 XI1_I746_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I56_MP5 (I1_I746_pn24 I1_b4_24 XI1_I746_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I56_MP4 (XI1_I746_I56_p1 XI1_I746_I56_An I1_I746_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I56_MP2 (VDD I1_p3_23 XI1_I746_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I56_MP3 (XI1_I746_I56_p1 XI1_I746_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I56_MP0 (VDD I1_p3_23 XI1_I746_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I62_MP1 (VDD I1_b4_30 XI1_I746_I62_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I62_MP5 (I1_I746_pn30 I1_b4_30 XI1_I746_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I62_MP4 (XI1_I746_I62_p1 XI1_I746_I62_An I1_I746_pn30 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I62_MP2 (VDD I1_p3_29 XI1_I746_I62_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I62_MP3 (XI1_I746_I62_p1 XI1_I746_I62_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I62_MP0 (VDD I1_p3_29 XI1_I746_I62_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I61_MP1 (VDD I1_b18_29 XI1_I1390_I61_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I61_MP5 (I1_I1390_pn29 I1_b18_29 XI1_I1390_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I61_MP4 (XI1_I1390_I61_p1 XI1_I1390_I61_An I1_I1390_pn29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I61_MP2 (VDD I1_p17_28 XI1_I1390_I61_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I61_MP3 (XI1_I1390_I61_p1 XI1_I1390_I61_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I61_MP0 (VDD I1_p17_28 XI1_I1390_I61_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I230_MP1 (VDD I1_I1344_G26_0 XI1_I1344_I230_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I230_MP5 (I1_p17_27 I1_I1344_G26_0 XI1_I1344_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I230_MP4 (XI1_I1344_I230_p1 XI1_I1344_I230_An I1_p17_27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I230_MP2 (VDD I1_I1344_pn27 XI1_I1344_I230_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I230_MP3 (XI1_I1344_I230_p1 XI1_I1344_I230_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I230_MP0 (VDD I1_I1344_pn27 XI1_I1344_I230_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I232_MP1 (VDD I1_I1344_G28_0 XI1_I1344_I232_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I232_MP5 (I1_p17_29 I1_I1344_G28_0 XI1_I1344_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I232_MP4 (XI1_I1344_I232_p1 XI1_I1344_I232_An I1_p17_29 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I232_MP2 (VDD I1_I1344_pn29 XI1_I1344_I232_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I232_MP3 (XI1_I1344_I232_p1 XI1_I1344_I232_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I232_MP0 (VDD I1_I1344_pn29 XI1_I1344_I232_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I51_MP1 (VDD I1_b17_19 XI1_I1344_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I51_MP5 (I1_I1344_pn19 I1_b17_19 XI1_I1344_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I51_MP4 (XI1_I1344_I51_p1 XI1_I1344_I51_An I1_I1344_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I51_MP2 (VDD I1_p16_18 XI1_I1344_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I51_MP3 (XI1_I1344_I51_p1 XI1_I1344_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I51_MP0 (VDD I1_p16_18 XI1_I1344_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I46_MP1 (VDD I1_b17_14 XI1_I1344_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I46_MP5 (I1_I1344_pn14 I1_b17_14 XI1_I1344_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I46_MP4 (XI1_I1344_I46_p1 XI1_I1344_I46_An I1_I1344_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I46_MP2 (VDD I1_p16_13 XI1_I1344_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I46_MP3 (XI1_I1344_I46_p1 XI1_I1344_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I46_MP0 (VDD I1_p16_13 XI1_I1344_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I221_MP1 (VDD I1_I1298_G17_0 XI1_I1298_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I221_MP5 (I1_p16_18 I1_I1298_G17_0 XI1_I1298_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I221_MP4 (XI1_I1298_I221_p1 XI1_I1298_I221_An I1_p16_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I221_MP2 (VDD I1_I1298_pn18 XI1_I1298_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I221_MP3 (XI1_I1298_I221_p1 XI1_I1298_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I221_MP0 (VDD I1_I1298_pn18 XI1_I1298_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I47_MP1 (VDD I1_b16_15 XI1_I1298_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I47_MP5 (I1_I1298_pn15 I1_b16_15 XI1_I1298_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I47_MP4 (XI1_I1298_I47_p1 XI1_I1298_I47_An I1_I1298_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I47_MP2 (VDD I1_p15_14 XI1_I1298_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I47_MP3 (XI1_I1298_I47_p1 XI1_I1298_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I47_MP0 (VDD I1_p15_14 XI1_I1298_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I48_MP1 (VDD I1_b15_16 XI1_I1252_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I48_MP5 (I1_I1252_pn16 I1_b15_16 XI1_I1252_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I48_MP4 (XI1_I1252_I48_p1 XI1_I1252_I48_An I1_I1252_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I48_MP2 (VDD I1_p14_15 XI1_I1252_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I48_MP3 (XI1_I1252_I48_p1 XI1_I1252_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I48_MP0 (VDD I1_p14_15 XI1_I1252_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I49_MP1 (VDD I1_b15_17 XI1_I1252_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I49_MP5 (I1_I1252_pn17 I1_b15_17 XI1_I1252_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I49_MP4 (XI1_I1252_I49_p1 XI1_I1252_I49_An I1_I1252_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I49_MP2 (VDD I1_p14_16 XI1_I1252_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I49_MP3 (XI1_I1252_I49_p1 XI1_I1252_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I49_MP0 (VDD I1_p14_16 XI1_I1252_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I47_MP1 (VDD I1_b15_15 XI1_I1252_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I47_MP5 (I1_I1252_pn15 I1_b15_15 XI1_I1252_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I47_MP4 (XI1_I1252_I47_p1 XI1_I1252_I47_An I1_I1252_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I47_MP2 (VDD I1_p14_14 XI1_I1252_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I47_MP3 (XI1_I1252_I47_p1 XI1_I1252_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I47_MP0 (VDD I1_p14_14 XI1_I1252_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I220_MP1 (VDD I1_I1206_G16_0 XI1_I1206_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I220_MP5 (I1_p14_17 I1_I1206_G16_0 XI1_I1206_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I220_MP4 (XI1_I1206_I220_p1 XI1_I1206_I220_An I1_p14_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I220_MP2 (VDD I1_I1206_pn17 XI1_I1206_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I220_MP3 (XI1_I1206_I220_p1 XI1_I1206_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I220_MP0 (VDD I1_I1206_pn17 XI1_I1206_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I221_MP1 (VDD I1_I1206_G17_0 XI1_I1206_I221_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I221_MP5 (I1_p14_18 I1_I1206_G17_0 XI1_I1206_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I221_MP4 (XI1_I1206_I221_p1 XI1_I1206_I221_An I1_p14_18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I221_MP2 (VDD I1_I1206_pn18 XI1_I1206_I221_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I221_MP3 (XI1_I1206_I221_p1 XI1_I1206_I221_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I221_MP0 (VDD I1_I1206_pn18 XI1_I1206_I221_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I60_MP1 (VDD I1_b7_28 XI1_I884_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I60_MP5 (I1_I884_pn28 I1_b7_28 XI1_I884_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I60_MP4 (XI1_I884_I60_p1 XI1_I884_I60_An I1_I884_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I60_MP2 (VDD I1_p6_27 XI1_I884_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I60_MP3 (XI1_I884_I60_p1 XI1_I884_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I60_MP0 (VDD I1_p6_27 XI1_I884_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I58_MP1 (VDD I1_b7_26 XI1_I884_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I58_MP5 (I1_I884_pn26 I1_b7_26 XI1_I884_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I58_MP4 (XI1_I884_I58_p1 XI1_I884_I58_An I1_I884_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I58_MP2 (VDD I1_p6_25 XI1_I884_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I58_MP3 (XI1_I884_I58_p1 XI1_I884_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I58_MP0 (VDD I1_p6_25 XI1_I884_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I56_MP1 (VDD I1_b7_24 XI1_I884_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I56_MP5 (I1_I884_pn24 I1_b7_24 XI1_I884_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I56_MP4 (XI1_I884_I56_p1 XI1_I884_I56_An I1_I884_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I56_MP2 (VDD I1_p6_23 XI1_I884_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I56_MP3 (XI1_I884_I56_p1 XI1_I884_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I56_MP0 (VDD I1_p6_23 XI1_I884_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I54_MP1 (VDD I1_b7_22 XI1_I884_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I54_MP5 (I1_I884_pn22 I1_b7_22 XI1_I884_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I54_MP4 (XI1_I884_I54_p1 XI1_I884_I54_An I1_I884_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I54_MP2 (VDD I1_p6_21 XI1_I884_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I54_MP3 (XI1_I884_I54_p1 XI1_I884_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I54_MP0 (VDD I1_p6_21 XI1_I884_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I52_MP1 (VDD I1_b7_20 XI1_I884_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I52_MP5 (I1_I884_pn20 I1_b7_20 XI1_I884_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I52_MP4 (XI1_I884_I52_p1 XI1_I884_I52_An I1_I884_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I52_MP2 (VDD I1_p6_19 XI1_I884_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I52_MP3 (XI1_I884_I52_p1 XI1_I884_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I52_MP0 (VDD I1_p6_19 XI1_I884_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I50_MP1 (VDD I1_b7_18 XI1_I884_I50_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I50_MP5 (I1_I884_pn18 I1_b7_18 XI1_I884_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I50_MP4 (XI1_I884_I50_p1 XI1_I884_I50_An I1_I884_pn18 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I50_MP2 (VDD I1_p6_17 XI1_I884_I50_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I50_MP3 (XI1_I884_I50_p1 XI1_I884_I50_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I50_MP0 (VDD I1_p6_17 XI1_I884_I50_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I49_MP1 (VDD I1_b7_17 XI1_I884_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I49_MP5 (I1_I884_pn17 I1_b7_17 XI1_I884_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I49_MP4 (XI1_I884_I49_p1 XI1_I884_I49_An I1_I884_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I49_MP2 (VDD I1_p6_16 XI1_I884_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I49_MP3 (XI1_I884_I49_p1 XI1_I884_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I49_MP0 (VDD I1_p6_16 XI1_I884_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I220_MP1 (VDD I1_I838_G16_0 XI1_I838_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I220_MP5 (I1_p6_17 I1_I838_G16_0 XI1_I838_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I220_MP4 (XI1_I838_I220_p1 XI1_I838_I220_An I1_p6_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I220_MP2 (VDD I1_I838_pn17 XI1_I838_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I220_MP3 (XI1_I838_I220_p1 XI1_I838_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I220_MP0 (VDD I1_I838_pn17 XI1_I838_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I208_MP1 (VDD I1_I838_G4_0 XI1_I838_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I208_MP5 (I1_p6_5 I1_I838_G4_0 XI1_I838_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I208_MP4 (XI1_I838_I208_p1 XI1_I838_I208_An I1_p6_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I208_MP2 (VDD I1_I838_pn5 XI1_I838_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I208_MP3 (XI1_I838_I208_p1 XI1_I838_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I208_MP0 (VDD I1_I838_pn5 XI1_I838_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I38_MP1 (VDD I1_b6_6 XI1_I838_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I38_MP5 (I1_I838_pn6 I1_b6_6 XI1_I838_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I38_MP4 (XI1_I838_I38_p1 XI1_I838_I38_An I1_I838_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I38_MP2 (VDD I1_p5_5 XI1_I838_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I38_MP3 (XI1_I838_I38_p1 XI1_I838_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I38_MP0 (VDD I1_p5_5 XI1_I838_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I37_MP1 (VDD I1_b6_5 XI1_I838_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I37_MP5 (I1_I838_pn5 I1_b6_5 XI1_I838_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I37_MP4 (XI1_I838_I37_p1 XI1_I838_I37_An I1_I838_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I37_MP2 (VDD I1_p5_4 XI1_I838_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I37_MP3 (XI1_I838_I37_p1 XI1_I838_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I37_MP0 (VDD I1_p5_4 XI1_I838_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I208_MP1 (VDD I1_I792_G4_0 XI1_I792_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I208_MP5 (I1_p5_5 I1_I792_G4_0 XI1_I792_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I208_MP4 (XI1_I792_I208_p1 XI1_I792_I208_An I1_p5_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I208_MP2 (VDD I1_I792_pn5 XI1_I792_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I208_MP3 (XI1_I792_I208_p1 XI1_I792_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I208_MP0 (VDD I1_I792_pn5 XI1_I792_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I42_MP1 (VDD I1_b5_10 XI1_I792_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I42_MP5 (I1_I792_pn10 I1_b5_10 XI1_I792_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I42_MP4 (XI1_I792_I42_p1 XI1_I792_I42_An I1_I792_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I42_MP2 (VDD I1_p4_9 XI1_I792_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I42_MP3 (XI1_I792_I42_p1 XI1_I792_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I42_MP0 (VDD I1_p4_9 XI1_I792_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I44_MP1 (VDD I1_b5_12 XI1_I792_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I44_MP5 (I1_I792_pn12 I1_b5_12 XI1_I792_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I44_MP4 (XI1_I792_I44_p1 XI1_I792_I44_An I1_I792_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I44_MP2 (VDD I1_p4_11 XI1_I792_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I44_MP3 (XI1_I792_I44_p1 XI1_I792_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I44_MP0 (VDD I1_p4_11 XI1_I792_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I45_MP1 (VDD I1_b5_13 XI1_I792_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I45_MP5 (I1_I792_pn13 I1_b5_13 XI1_I792_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I45_MP4 (XI1_I792_I45_p1 XI1_I792_I45_An I1_I792_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I45_MP2 (VDD I1_p4_12 XI1_I792_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I45_MP3 (XI1_I792_I45_p1 XI1_I792_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I45_MP0 (VDD I1_p4_12 XI1_I792_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I46_MP1 (VDD I1_b5_14 XI1_I792_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I46_MP5 (I1_I792_pn14 I1_b5_14 XI1_I792_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I46_MP4 (XI1_I792_I46_p1 XI1_I792_I46_An I1_I792_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I46_MP2 (VDD I1_p4_13 XI1_I792_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I46_MP3 (XI1_I792_I46_p1 XI1_I792_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I46_MP0 (VDD I1_p4_13 XI1_I792_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I223_MP1 (VDD I1_I746_G19_0 XI1_I746_I223_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I223_MP5 (I1_p4_20 I1_I746_G19_0 XI1_I746_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I223_MP4 (XI1_I746_I223_p1 XI1_I746_I223_An I1_p4_20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I223_MP2 (VDD I1_I746_pn20 XI1_I746_I223_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I223_MP3 (XI1_I746_I223_p1 XI1_I746_I223_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I223_MP0 (VDD I1_I746_pn20 XI1_I746_I223_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I63_MP1 (VDD I1_b4_31 XI1_I746_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I63_MP5 (I1_I746_pn31 I1_b4_31 XI1_I746_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I63_MP4 (XI1_I746_I63_p1 XI1_I746_I63_An I1_I746_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I63_MP2 (VDD I1_p3_30 XI1_I746_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I63_MP3 (XI1_I746_I63_p1 XI1_I746_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I63_MP0 (VDD I1_p3_30 XI1_I746_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I59_MP1 (VDD I1_b18_27 XI1_I1390_I59_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I59_MP5 (I1_I1390_pn27 I1_b18_27 XI1_I1390_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I59_MP4 (XI1_I1390_I59_p1 XI1_I1390_I59_An I1_I1390_pn27 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I59_MP2 (VDD I1_p17_26 XI1_I1390_I59_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I59_MP3 (XI1_I1390_I59_p1 XI1_I1390_I59_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I59_MP0 (VDD I1_p17_26 XI1_I1390_I59_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I57_MP1 (VDD I1_b18_25 XI1_I1390_I57_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I57_MP5 (I1_I1390_pn25 I1_b18_25 XI1_I1390_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I57_MP4 (XI1_I1390_I57_p1 XI1_I1390_I57_An I1_I1390_pn25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I57_MP2 (VDD I1_p17_24 XI1_I1390_I57_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I57_MP3 (XI1_I1390_I57_p1 XI1_I1390_I57_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I57_MP0 (VDD I1_p17_24 XI1_I1390_I57_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I228_MP1 (VDD I1_I1344_G24_0 XI1_I1344_I228_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I228_MP5 (I1_p17_25 I1_I1344_G24_0 XI1_I1344_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I228_MP4 (XI1_I1344_I228_p1 XI1_I1344_I228_An I1_p17_25 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I228_MP2 (VDD I1_I1344_pn25 XI1_I1344_I228_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I228_MP3 (XI1_I1344_I228_p1 XI1_I1344_I228_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I228_MP0 (VDD I1_I1344_pn25 XI1_I1344_I228_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I224_MP1 (VDD I1_I1344_G20_0 XI1_I1344_I224_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I224_MP5 (I1_p17_21 I1_I1344_G20_0 XI1_I1344_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I224_MP4 (XI1_I1344_I224_p1 XI1_I1344_I224_An I1_p17_21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I224_MP2 (VDD I1_I1344_pn21 XI1_I1344_I224_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I224_MP3 (XI1_I1344_I224_p1 XI1_I1344_I224_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I224_MP0 (VDD I1_I1344_pn21 XI1_I1344_I224_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I44_MP1 (VDD I1_b17_12 XI1_I1344_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I44_MP5 (I1_I1344_pn12 I1_b17_12 XI1_I1344_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I44_MP4 (XI1_I1344_I44_p1 XI1_I1344_I44_An I1_I1344_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I44_MP2 (VDD I1_p16_11 XI1_I1344_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I44_MP3 (XI1_I1344_I44_p1 XI1_I1344_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I44_MP0 (VDD I1_p16_11 XI1_I1344_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I45_MP1 (VDD I1_b17_13 XI1_I1344_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I45_MP5 (I1_I1344_pn13 I1_b17_13 XI1_I1344_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I45_MP4 (XI1_I1344_I45_p1 XI1_I1344_I45_An I1_I1344_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I45_MP2 (VDD I1_p16_12 XI1_I1344_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I45_MP3 (XI1_I1344_I45_p1 XI1_I1344_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I45_MP0 (VDD I1_p16_12 XI1_I1344_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I45_MP1 (VDD I1_b16_13 XI1_I1298_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I45_MP5 (I1_I1298_pn13 I1_b16_13 XI1_I1298_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I45_MP4 (XI1_I1298_I45_p1 XI1_I1298_I45_An I1_I1298_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I45_MP2 (VDD I1_p15_12 XI1_I1298_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I45_MP3 (XI1_I1298_I45_p1 XI1_I1298_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I45_MP0 (VDD I1_p15_12 XI1_I1298_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I46_MP1 (VDD I1_b16_14 XI1_I1298_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I46_MP5 (I1_I1298_pn14 I1_b16_14 XI1_I1298_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I46_MP4 (XI1_I1298_I46_p1 XI1_I1298_I46_An I1_I1298_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I46_MP2 (VDD I1_p15_13 XI1_I1298_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I46_MP3 (XI1_I1298_I46_p1 XI1_I1298_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I46_MP0 (VDD I1_p15_13 XI1_I1298_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I45_MP1 (VDD I1_b15_13 XI1_I1252_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I45_MP5 (I1_I1252_pn13 I1_b15_13 XI1_I1252_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I45_MP4 (XI1_I1252_I45_p1 XI1_I1252_I45_An I1_I1252_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I45_MP2 (VDD I1_p14_12 XI1_I1252_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I45_MP3 (XI1_I1252_I45_p1 XI1_I1252_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I45_MP0 (VDD I1_p14_12 XI1_I1252_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I46_MP1 (VDD I1_b15_14 XI1_I1252_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I46_MP5 (I1_I1252_pn14 I1_b15_14 XI1_I1252_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I46_MP4 (XI1_I1252_I46_p1 XI1_I1252_I46_An I1_I1252_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I46_MP2 (VDD I1_p14_13 XI1_I1252_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I46_MP3 (XI1_I1252_I46_p1 XI1_I1252_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I46_MP0 (VDD I1_p14_13 XI1_I1252_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I48_MP1 (VDD I1_b14_16 XI1_I1206_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I48_MP5 (I1_I1206_pn16 I1_b14_16 XI1_I1206_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I48_MP4 (XI1_I1206_I48_p1 XI1_I1206_I48_An I1_I1206_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I48_MP2 (VDD I1_p13_15 XI1_I1206_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I48_MP3 (XI1_I1206_I48_p1 XI1_I1206_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I48_MP0 (VDD I1_p13_15 XI1_I1206_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I49_MP1 (VDD I1_b14_17 XI1_I1206_I49_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I49_MP5 (I1_I1206_pn17 I1_b14_17 XI1_I1206_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I49_MP4 (XI1_I1206_I49_p1 XI1_I1206_I49_An I1_I1206_pn17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I49_MP2 (VDD I1_p13_16 XI1_I1206_I49_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I49_MP3 (XI1_I1206_I49_p1 XI1_I1206_I49_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I49_MP0 (VDD I1_p13_16 XI1_I1206_I49_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I47_MP1 (VDD I1_b14_15 XI1_I1206_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I47_MP5 (I1_I1206_pn15 I1_b14_15 XI1_I1206_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I47_MP4 (XI1_I1206_I47_p1 XI1_I1206_I47_An I1_I1206_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I47_MP2 (VDD I1_p13_14 XI1_I1206_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I47_MP3 (XI1_I1206_I47_p1 XI1_I1206_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I47_MP0 (VDD I1_p13_14 XI1_I1206_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I63_MP1 (VDD I1_b7_31 XI1_I884_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I63_MP5 (I1_I884_pn31 I1_b7_31 XI1_I884_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I63_MP4 (XI1_I884_I63_p1 XI1_I884_I63_An I1_I884_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I63_MP2 (VDD I1_p6_30 XI1_I884_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I63_MP3 (XI1_I884_I63_p1 XI1_I884_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I63_MP0 (VDD I1_p6_30 XI1_I884_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I53_MP1 (VDD I1_b7_21 XI1_I884_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I53_MP5 (I1_I884_pn21 I1_b7_21 XI1_I884_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I53_MP4 (XI1_I884_I53_p1 XI1_I884_I53_An I1_I884_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I53_MP2 (VDD I1_p6_20 XI1_I884_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I53_MP3 (XI1_I884_I53_p1 XI1_I884_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I53_MP0 (VDD I1_p6_20 XI1_I884_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I51_MP1 (VDD I1_b7_19 XI1_I884_I51_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I51_MP5 (I1_I884_pn19 I1_b7_19 XI1_I884_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I51_MP4 (XI1_I884_I51_p1 XI1_I884_I51_An I1_I884_pn19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I51_MP2 (VDD I1_p6_18 XI1_I884_I51_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I51_MP3 (XI1_I884_I51_p1 XI1_I884_I51_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I51_MP0 (VDD I1_p6_18 XI1_I884_I51_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I48_MP1 (VDD I1_b7_16 XI1_I884_I48_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I48_MP5 (I1_I884_pn16 I1_b7_16 XI1_I884_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I48_MP4 (XI1_I884_I48_p1 XI1_I884_I48_An I1_I884_pn16 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I48_MP2 (VDD I1_p6_15 XI1_I884_I48_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I48_MP3 (XI1_I884_I48_p1 XI1_I884_I48_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I48_MP0 (VDD I1_p6_15 XI1_I884_I48_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I47_MP1 (VDD I1_b7_15 XI1_I884_I47_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I47_MP5 (I1_I884_pn15 I1_b7_15 XI1_I884_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I47_MP4 (XI1_I884_I47_p1 XI1_I884_I47_An I1_I884_pn15 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I47_MP2 (VDD I1_p6_14 XI1_I884_I47_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I47_MP3 (XI1_I884_I47_p1 XI1_I884_I47_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I47_MP0 (VDD I1_p6_14 XI1_I884_I47_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I46_MP1 (VDD I1_b7_14 XI1_I884_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I46_MP5 (I1_I884_pn14 I1_b7_14 XI1_I884_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I46_MP4 (XI1_I884_I46_p1 XI1_I884_I46_An I1_I884_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I46_MP2 (VDD I1_p6_13 XI1_I884_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I46_MP3 (XI1_I884_I46_p1 XI1_I884_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I46_MP0 (VDD I1_p6_13 XI1_I884_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I45_MP1 (VDD I1_b7_13 XI1_I884_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I45_MP5 (I1_I884_pn13 I1_b7_13 XI1_I884_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I45_MP4 (XI1_I884_I45_p1 XI1_I884_I45_An I1_I884_pn13 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I45_MP2 (VDD I1_p6_12 XI1_I884_I45_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I45_MP3 (XI1_I884_I45_p1 XI1_I884_I45_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I45_MP0 (VDD I1_p6_12 XI1_I884_I45_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I43_MP1 (VDD I1_b7_11 XI1_I884_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I43_MP5 (I1_I884_pn11 I1_b7_11 XI1_I884_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I43_MP4 (XI1_I884_I43_p1 XI1_I884_I43_An I1_I884_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I43_MP2 (VDD I1_p6_10 XI1_I884_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I43_MP3 (XI1_I884_I43_p1 XI1_I884_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I43_MP0 (VDD I1_p6_10 XI1_I884_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I36_MP1 (VDD I1_b6_4 XI1_I838_I36_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I36_MP5 (I1_I838_pn4 I1_b6_4 XI1_I838_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I36_MP4 (XI1_I838_I36_p1 XI1_I838_I36_An I1_I838_pn4 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I36_MP2 (VDD I1_p5_3 XI1_I838_I36_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I36_MP3 (XI1_I838_I36_p1 XI1_I838_I36_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I36_MP0 (VDD I1_p5_3 XI1_I838_I36_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I38_MP1 (VDD I1_b5_6 XI1_I792_I38_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I38_MP5 (I1_I792_pn6 I1_b5_6 XI1_I792_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I38_MP4 (XI1_I792_I38_p1 XI1_I792_I38_An I1_I792_pn6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I38_MP2 (VDD I1_p4_5 XI1_I792_I38_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I38_MP3 (XI1_I792_I38_p1 XI1_I792_I38_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I38_MP0 (VDD I1_p4_5 XI1_I792_I38_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I40_MP1 (VDD I1_b5_8 XI1_I792_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I40_MP5 (I1_I792_pn8 I1_b5_8 XI1_I792_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I40_MP4 (XI1_I792_I40_p1 XI1_I792_I40_An I1_I792_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I40_MP2 (VDD I1_p4_7 XI1_I792_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I40_MP3 (XI1_I792_I40_p1 XI1_I792_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I40_MP0 (VDD I1_p4_7 XI1_I792_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I43_MP1 (VDD I1_b5_11 XI1_I792_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I43_MP5 (I1_I792_pn11 I1_b5_11 XI1_I792_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I43_MP4 (XI1_I792_I43_p1 XI1_I792_I43_An I1_I792_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I43_MP2 (VDD I1_p4_10 XI1_I792_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I43_MP3 (XI1_I792_I43_p1 XI1_I792_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I43_MP0 (VDD I1_p4_10 XI1_I792_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I210_MP1 (VDD I1_I746_G6_0 XI1_I746_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I210_MP5 (I1_p4_7 I1_I746_G6_0 XI1_I746_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I210_MP4 (XI1_I746_I210_p1 XI1_I746_I210_An I1_p4_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I210_MP2 (VDD I1_I746_pn7 XI1_I746_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I210_MP3 (XI1_I746_I210_p1 XI1_I746_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I210_MP0 (VDD I1_I746_pn7 XI1_I746_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I60_MP1 (VDD I1_b18_28 XI1_I1390_I60_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I60_MP5 (I1_I1390_pn28 I1_b18_28 XI1_I1390_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I60_MP4 (XI1_I1390_I60_p1 XI1_I1390_I60_An I1_I1390_pn28 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I60_MP2 (VDD I1_p17_27 XI1_I1390_I60_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I60_MP3 (XI1_I1390_I60_p1 XI1_I1390_I60_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I60_MP0 (VDD I1_p17_27 XI1_I1390_I60_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I226_MP1 (VDD I1_I1344_G22_0 XI1_I1344_I226_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I226_MP5 (I1_p17_23 I1_I1344_G22_0 XI1_I1344_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I226_MP4 (XI1_I1344_I226_p1 XI1_I1344_I226_An I1_p17_23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I226_MP2 (VDD I1_I1344_pn23 XI1_I1344_I226_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I226_MP3 (XI1_I1344_I226_p1 XI1_I1344_I226_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I226_MP0 (VDD I1_I1344_pn23 XI1_I1344_I226_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I43_MP1 (VDD I1_b17_11 XI1_I1344_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I43_MP5 (I1_I1344_pn11 I1_b17_11 XI1_I1344_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I43_MP4 (XI1_I1344_I43_p1 XI1_I1344_I43_An I1_I1344_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I43_MP2 (VDD I1_p16_10 XI1_I1344_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I43_MP3 (XI1_I1344_I43_p1 XI1_I1344_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I43_MP0 (VDD I1_p16_10 XI1_I1344_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I211_MP1 (VDD I1_I1298_G7_0 XI1_I1298_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I211_MP5 (I1_p16_8 I1_I1298_G7_0 XI1_I1298_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I211_MP4 (XI1_I1298_I211_p1 XI1_I1298_I211_An I1_p16_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I211_MP2 (VDD I1_I1298_pn8 XI1_I1298_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I211_MP3 (XI1_I1298_I211_p1 XI1_I1298_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I211_MP0 (VDD I1_I1298_pn8 XI1_I1298_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I44_MP1 (VDD I1_b16_12 XI1_I1298_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I44_MP5 (I1_I1298_pn12 I1_b16_12 XI1_I1298_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I44_MP4 (XI1_I1298_I44_p1 XI1_I1298_I44_An I1_I1298_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I44_MP2 (VDD I1_p15_11 XI1_I1298_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I44_MP3 (XI1_I1298_I44_p1 XI1_I1298_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I44_MP0 (VDD I1_p15_11 XI1_I1298_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I43_MP1 (VDD I1_b16_11 XI1_I1298_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I43_MP5 (I1_I1298_pn11 I1_b16_11 XI1_I1298_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I43_MP4 (XI1_I1298_I43_p1 XI1_I1298_I43_An I1_I1298_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I43_MP2 (VDD I1_p15_10 XI1_I1298_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I43_MP3 (XI1_I1298_I43_p1 XI1_I1298_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I43_MP0 (VDD I1_p15_10 XI1_I1298_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I43_MP1 (VDD I1_b15_11 XI1_I1252_I43_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I43_MP5 (I1_I1252_pn11 I1_b15_11 XI1_I1252_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I43_MP4 (XI1_I1252_I43_p1 XI1_I1252_I43_An I1_I1252_pn11 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I43_MP2 (VDD I1_p14_10 XI1_I1252_I43_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I43_MP3 (XI1_I1252_I43_p1 XI1_I1252_I43_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I43_MP0 (VDD I1_p14_10 XI1_I1252_I43_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I44_MP1 (VDD I1_b15_12 XI1_I1252_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I44_MP5 (I1_I1252_pn12 I1_b15_12 XI1_I1252_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I44_MP4 (XI1_I1252_I44_p1 XI1_I1252_I44_An I1_I1252_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I44_MP2 (VDD I1_p14_11 XI1_I1252_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I44_MP3 (XI1_I1252_I44_p1 XI1_I1252_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I44_MP0 (VDD I1_p14_11 XI1_I1252_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I46_MP1 (VDD I1_b14_14 XI1_I1206_I46_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I46_MP5 (I1_I1206_pn14 I1_b14_14 XI1_I1206_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1206_I46_MP4 (XI1_I1206_I46_p1 XI1_I1206_I46_An I1_I1206_pn14 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I46_MP2 (VDD I1_p13_13 XI1_I1206_I46_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1206_I46_MP3 (XI1_I1206_I46_p1 XI1_I1206_I46_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1206_I46_MP0 (VDD I1_p13_13 XI1_I1206_I46_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I44_MP1 (VDD I1_b7_12 XI1_I884_I44_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I44_MP5 (I1_I884_pn12 I1_b7_12 XI1_I884_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I44_MP4 (XI1_I884_I44_p1 XI1_I884_I44_An I1_I884_pn12 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I44_MP2 (VDD I1_p6_11 XI1_I884_I44_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I44_MP3 (XI1_I884_I44_p1 XI1_I884_I44_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I44_MP0 (VDD I1_p6_11 XI1_I884_I44_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I42_MP1 (VDD I1_b7_10 XI1_I884_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I42_MP5 (I1_I884_pn10 I1_b7_10 XI1_I884_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I42_MP4 (XI1_I884_I42_p1 XI1_I884_I42_An I1_I884_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I42_MP2 (VDD I1_p6_9 XI1_I884_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I42_MP3 (XI1_I884_I42_p1 XI1_I884_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I42_MP0 (VDD I1_p6_9 XI1_I884_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I41_MP1 (VDD I1_b7_9 XI1_I884_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I884_I41_MP5 (I1_I884_pn9 I1_b7_9 XI1_I884_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I884_I41_MP4 (XI1_I884_I41_p1 XI1_I884_I41_An I1_I884_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I41_MP2 (VDD I1_p6_8 XI1_I884_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I884_I41_MP3 (XI1_I884_I41_p1 XI1_I884_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I884_I41_MP0 (VDD I1_p6_8 XI1_I884_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I35_MP1 (VDD I1_b6_3 XI1_I838_I35_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I838_I35_MP5 (I1_I838_pn3 I1_b6_3 XI1_I838_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I838_I35_MP4 (XI1_I838_I35_p1 XI1_I838_I35_An I1_I838_pn3 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I35_MP2 (VDD I1_p5_2 XI1_I838_I35_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I838_I35_MP3 (XI1_I838_I35_p1 XI1_I838_I35_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I838_I35_MP0 (VDD I1_p5_2 XI1_I838_I35_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I205_MP1 (VDD I1_I792_G1_0 XI1_I792_I205_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I205_MP5 (I1_p5_2 I1_I792_G1_0 XI1_I792_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I205_MP4 (XI1_I792_I205_p1 XI1_I792_I205_An I1_p5_2 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I205_MP2 (VDD I1_I792_pn2 XI1_I792_I205_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I205_MP3 (XI1_I792_I205_p1 XI1_I792_I205_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I205_MP0 (VDD I1_I792_pn2 XI1_I792_I205_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I37_MP1 (VDD I1_b5_5 XI1_I792_I37_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I37_MP5 (I1_I792_pn5 I1_b5_5 XI1_I792_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I37_MP4 (XI1_I792_I37_p1 XI1_I792_I37_An I1_I792_pn5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I37_MP2 (VDD I1_p4_4 XI1_I792_I37_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I37_MP3 (XI1_I792_I37_p1 XI1_I792_I37_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I37_MP0 (VDD I1_p4_4 XI1_I792_I37_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I39_MP1 (VDD I1_b5_7 XI1_I792_I39_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I39_MP5 (I1_I792_pn7 I1_b5_7 XI1_I792_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I39_MP4 (XI1_I792_I39_p1 XI1_I792_I39_An I1_I792_pn7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I39_MP2 (VDD I1_p4_6 XI1_I792_I39_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I39_MP3 (XI1_I792_I39_p1 XI1_I792_I39_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I39_MP0 (VDD I1_p4_6 XI1_I792_I39_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I41_MP1 (VDD I1_b5_9 XI1_I792_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I792_I41_MP5 (I1_I792_pn9 I1_b5_9 XI1_I792_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I792_I41_MP4 (XI1_I792_I41_p1 XI1_I792_I41_An I1_I792_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I41_MP2 (VDD I1_p4_8 XI1_I792_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I792_I41_MP3 (XI1_I792_I41_p1 XI1_I792_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I792_I41_MP0 (VDD I1_p4_8 XI1_I792_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I208_MP1 (VDD I1_I746_G4_0 XI1_I746_I208_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I208_MP5 (I1_p4_5 I1_I746_G4_0 XI1_I746_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I208_MP4 (XI1_I746_I208_p1 XI1_I746_I208_An I1_p4_5 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I208_MP2 (VDD I1_I746_pn5 XI1_I746_I208_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I208_MP3 (XI1_I746_I208_p1 XI1_I746_I208_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I208_MP0 (VDD I1_I746_pn5 XI1_I746_I208_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I209_MP1 (VDD I1_I746_G5_0 XI1_I746_I209_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I209_MP5 (I1_p4_6 I1_I746_G5_0 XI1_I746_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I209_MP4 (XI1_I746_I209_p1 XI1_I746_I209_An I1_p4_6 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I209_MP2 (VDD I1_I746_pn6 XI1_I746_I209_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I209_MP3 (XI1_I746_I209_p1 XI1_I746_I209_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I209_MP0 (VDD I1_I746_pn6 XI1_I746_I209_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I211_MP1 (VDD I1_I746_G7_0 XI1_I746_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I211_MP5 (I1_p4_8 I1_I746_G7_0 XI1_I746_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I211_MP4 (XI1_I746_I211_p1 XI1_I746_I211_An I1_p4_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I211_MP2 (VDD I1_I746_pn8 XI1_I746_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I211_MP3 (XI1_I746_I211_p1 XI1_I746_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I211_MP0 (VDD I1_I746_pn8 XI1_I746_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I53_MP1 (VDD I1_b4_21 XI1_I746_I53_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I53_MP5 (I1_I746_pn21 I1_b4_21 XI1_I746_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I53_MP4 (XI1_I746_I53_p1 XI1_I746_I53_An I1_I746_pn21 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I53_MP2 (VDD I1_p3_20 XI1_I746_I53_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I53_MP3 (XI1_I746_I53_p1 XI1_I746_I53_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I53_MP0 (VDD I1_p3_20 XI1_I746_I53_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I55_MP1 (VDD I1_b4_23 XI1_I746_I55_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I746_I55_MP5 (I1_I746_pn23 I1_b4_23 XI1_I746_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I746_I55_MP4 (XI1_I746_I55_p1 XI1_I746_I55_An I1_I746_pn23 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I55_MP2 (VDD I1_p3_22 XI1_I746_I55_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I746_I55_MP3 (XI1_I746_I55_p1 XI1_I746_I55_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I746_I55_MP0 (VDD I1_p3_22 XI1_I746_I55_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I63_MP1 (VDD I1_b18_31 XI1_I1390_I63_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I63_MP5 (I1_I1390_pn31 I1_b18_31 XI1_I1390_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I63_MP4 (XI1_I1390_I63_p1 XI1_I1390_I63_An I1_I1390_pn31 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I63_MP2 (VDD I1_p17_30 XI1_I1390_I63_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I63_MP3 (XI1_I1390_I63_p1 XI1_I1390_I63_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I63_MP0 (VDD I1_p17_30 XI1_I1390_I63_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I58_MP1 (VDD I1_b18_26 XI1_I1390_I58_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I58_MP5 (I1_I1390_pn26 I1_b18_26 XI1_I1390_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I58_MP4 (XI1_I1390_I58_p1 XI1_I1390_I58_An I1_I1390_pn26 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I58_MP2 (VDD I1_p17_25 XI1_I1390_I58_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I58_MP3 (XI1_I1390_I58_p1 XI1_I1390_I58_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I58_MP0 (VDD I1_p17_25 XI1_I1390_I58_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I56_MP1 (VDD I1_b18_24 XI1_I1390_I56_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I56_MP5 (I1_I1390_pn24 I1_b18_24 XI1_I1390_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I56_MP4 (XI1_I1390_I56_p1 XI1_I1390_I56_An I1_I1390_pn24 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I56_MP2 (VDD I1_p17_23 XI1_I1390_I56_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I56_MP3 (XI1_I1390_I56_p1 XI1_I1390_I56_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I56_MP0 (VDD I1_p17_23 XI1_I1390_I56_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I54_MP1 (VDD I1_b18_22 XI1_I1390_I54_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I54_MP5 (I1_I1390_pn22 I1_b18_22 XI1_I1390_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I54_MP4 (XI1_I1390_I54_p1 XI1_I1390_I54_An I1_I1390_pn22 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I54_MP2 (VDD I1_p17_21 XI1_I1390_I54_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I54_MP3 (XI1_I1390_I54_p1 XI1_I1390_I54_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I54_MP0 (VDD I1_p17_21 XI1_I1390_I54_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I52_MP1 (VDD I1_b18_20 XI1_I1390_I52_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1390_I52_MP5 (I1_I1390_pn20 I1_b18_20 XI1_I1390_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1390_I52_MP4 (XI1_I1390_I52_p1 XI1_I1390_I52_An I1_I1390_pn20 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I52_MP2 (VDD I1_p17_19 XI1_I1390_I52_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1390_I52_MP3 (XI1_I1390_I52_p1 XI1_I1390_I52_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1390_I52_MP0 (VDD I1_p17_19 XI1_I1390_I52_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I222_MP1 (VDD I1_I1344_G18_0 XI1_I1344_I222_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I222_MP5 (I1_p17_19 I1_I1344_G18_0 XI1_I1344_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I222_MP4 (XI1_I1344_I222_p1 XI1_I1344_I222_An I1_p17_19 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I222_MP2 (VDD I1_I1344_pn19 XI1_I1344_I222_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I222_MP3 (XI1_I1344_I222_p1 XI1_I1344_I222_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I222_MP0 (VDD I1_I1344_pn19 XI1_I1344_I222_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I220_MP1 (VDD I1_I1344_G16_0 XI1_I1344_I220_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I220_MP5 (I1_p17_17 I1_I1344_G16_0 XI1_I1344_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I220_MP4 (XI1_I1344_I220_p1 XI1_I1344_I220_An I1_p17_17 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I220_MP2 (VDD I1_I1344_pn17 XI1_I1344_I220_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I220_MP3 (XI1_I1344_I220_p1 XI1_I1344_I220_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I220_MP0 (VDD I1_I1344_pn17 XI1_I1344_I220_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I211_MP1 (VDD I1_I1344_G7_0 XI1_I1344_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I211_MP5 (I1_p17_8 I1_I1344_G7_0 XI1_I1344_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I211_MP4 (XI1_I1344_I211_p1 XI1_I1344_I211_An I1_p17_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I211_MP2 (VDD I1_I1344_pn8 XI1_I1344_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I211_MP3 (XI1_I1344_I211_p1 XI1_I1344_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I211_MP0 (VDD I1_I1344_pn8 XI1_I1344_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I42_MP1 (VDD I1_b17_10 XI1_I1344_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I42_MP5 (I1_I1344_pn10 I1_b17_10 XI1_I1344_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I42_MP4 (XI1_I1344_I42_p1 XI1_I1344_I42_An I1_I1344_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I42_MP2 (VDD I1_p16_9 XI1_I1344_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I42_MP3 (XI1_I1344_I42_p1 XI1_I1344_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I42_MP0 (VDD I1_p16_9 XI1_I1344_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I41_MP1 (VDD I1_b17_9 XI1_I1344_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I41_MP5 (I1_I1344_pn9 I1_b17_9 XI1_I1344_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I41_MP4 (XI1_I1344_I41_p1 XI1_I1344_I41_An I1_I1344_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I41_MP2 (VDD I1_p16_8 XI1_I1344_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I41_MP3 (XI1_I1344_I41_p1 XI1_I1344_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I41_MP0 (VDD I1_p16_8 XI1_I1344_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I40_MP1 (VDD I1_b17_8 XI1_I1344_I40_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1344_I40_MP5 (I1_I1344_pn8 I1_b17_8 XI1_I1344_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1344_I40_MP4 (XI1_I1344_I40_p1 XI1_I1344_I40_An I1_I1344_pn8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I40_MP2 (VDD I1_p16_7 XI1_I1344_I40_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1344_I40_MP3 (XI1_I1344_I40_p1 XI1_I1344_I40_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1344_I40_MP0 (VDD I1_p16_7 XI1_I1344_I40_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I210_MP1 (VDD I1_I1298_G6_0 XI1_I1298_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I210_MP5 (I1_p16_7 I1_I1298_G6_0 XI1_I1298_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I210_MP4 (XI1_I1298_I210_p1 XI1_I1298_I210_An I1_p16_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I210_MP2 (VDD I1_I1298_pn7 XI1_I1298_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I210_MP3 (XI1_I1298_I210_p1 XI1_I1298_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I210_MP0 (VDD I1_I1298_pn7 XI1_I1298_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I42_MP1 (VDD I1_b16_10 XI1_I1298_I42_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I42_MP5 (I1_I1298_pn10 I1_b16_10 XI1_I1298_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I42_MP4 (XI1_I1298_I42_p1 XI1_I1298_I42_An I1_I1298_pn10 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I42_MP2 (VDD I1_p15_9 XI1_I1298_I42_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I42_MP3 (XI1_I1298_I42_p1 XI1_I1298_I42_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I42_MP0 (VDD I1_p15_9 XI1_I1298_I42_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I41_MP1 (VDD I1_b16_9 XI1_I1298_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1298_I41_MP5 (I1_I1298_pn9 I1_b16_9 XI1_I1298_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1298_I41_MP4 (XI1_I1298_I41_p1 XI1_I1298_I41_An I1_I1298_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I41_MP2 (VDD I1_p15_8 XI1_I1298_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1298_I41_MP3 (XI1_I1298_I41_p1 XI1_I1298_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1298_I41_MP0 (VDD I1_p15_8 XI1_I1298_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I210_MP1 (VDD I1_I1252_G6_0 XI1_I1252_I210_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I210_MP5 (I1_p15_7 I1_I1252_G6_0 XI1_I1252_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I210_MP4 (XI1_I1252_I210_p1 XI1_I1252_I210_An I1_p15_7 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I210_MP2 (VDD I1_I1252_pn7 XI1_I1252_I210_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I210_MP3 (XI1_I1252_I210_p1 XI1_I1252_I210_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I210_MP0 (VDD I1_I1252_pn7 XI1_I1252_I210_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I211_MP1 (VDD I1_I1252_G7_0 XI1_I1252_I211_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I211_MP5 (I1_p15_8 I1_I1252_G7_0 XI1_I1252_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I211_MP4 (XI1_I1252_I211_p1 XI1_I1252_I211_An I1_p15_8 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I211_MP2 (VDD I1_I1252_pn8 XI1_I1252_I211_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I211_MP3 (XI1_I1252_I211_p1 XI1_I1252_I211_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I211_MP0 (VDD I1_I1252_pn8 XI1_I1252_I211_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I41_MP1 (VDD I1_b15_9 XI1_I1252_I41_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1252_I41_MP5 (I1_I1252_pn9 I1_b15_9 XI1_I1252_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1632p pd=0.92u ps=1.64u
    I_MXI1_I1252_I41_MP4 (XI1_I1252_I41_p1 XI1_I1252_I41_An I1_I1252_pn9 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I41_MP2 (VDD I1_p14_8 XI1_I1252_I41_p1 VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1056p as=0.1056p pd=0.92u ps=0.92u
    I_MXI1_I1252_I41_MP3 (XI1_I1252_I41_p1 XI1_I1252_I41_Bn VDD VDD) gpdk090_pmos1v w=0.48u l=0.1u ad=0.1632p as=0.1056p pd=1.64u ps=0.92u
    I_MXI1_I1252_I41_MP0 (VDD I1_p14_8 XI1_I1252_I41_An VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
    I_MXI1_I1206_I45_MP1 (VDD I1_b14_13 XI1_I1206_I45_Bn VDD) gpdk090_pmos1v w=0.24u l=0.1u ad=0.0816p as=0.0816p pd=1.16u ps=1.16u
