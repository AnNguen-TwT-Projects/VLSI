    I_MXI1_I1850_I141_XG_MN1 (XI1_I1850_I141_XG_n1 I1_I1850_G12_9n I1_I1850_G16_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I183_XG_MN2 (XI1_I1850_I183_XG_n1 I1_I1850_G16_1n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I183_XG_MN0 (I1_I1850_G16_0 I1_I1850_P16_1n XI1_I1850_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I183_XG_MN1 (XI1_I1850_I183_XG_n1 I1_I1850_G0_0n I1_I1850_G16_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I83_XG_MN2 (XI1_I1896_I83_XG_n1 I1_I1896_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I83_XG_MN0 (I1_I1896_G17_16 I1_I1896_pn17 XI1_I1896_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I83_XG_MN1 (XI1_I1896_I83_XG_n1 I1_I1896_gn16 I1_I1896_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I82_XG_MN2 (XI1_I1896_I82_XG_n1 I1_I1896_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I82_XG_MN0 (I1_I1896_G16_15 I1_I1896_pn16 XI1_I1896_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I82_XG_MN1 (XI1_I1896_I82_XG_n1 I1_I1896_gn15 I1_I1896_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I81_XG_MN2 (XI1_I1896_I81_XG_n1 I1_I1896_gn15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I81_XG_MN0 (I1_I1896_G15_14 I1_I1896_pn15 XI1_I1896_I81_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I81_XG_MN1 (XI1_I1896_I81_XG_n1 I1_I1896_gn14 I1_I1896_G15_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I140_XG_MN2 (XI1_I1896_I140_XG_n1 I1_I1896_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I140_XG_MN0 (I1_I1896_G15_8 I1_I1896_P15_12n XI1_I1896_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I140_XG_MN1 (XI1_I1896_I140_XG_n1 I1_I1896_G11_8n I1_I1896_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I139_XG_MN2 (XI1_I1896_I139_XG_n1 I1_I1896_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I139_XG_MN0 (I1_I1896_G14_7 I1_I1896_P14_11n XI1_I1896_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I139_XG_MN1 (XI1_I1896_I139_XG_n1 I1_I1896_G10_7n I1_I1896_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I84_XG_MN2 (XI1_I1942_I84_XG_n1 I1_I1942_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I84_XG_MN0 (I1_I1942_G18_17 I1_I1942_pn18 XI1_I1942_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I84_XG_MN1 (XI1_I1942_I84_XG_n1 I1_I1942_gn17 I1_I1942_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I146_XG_MN2 (XI1_I1942_I146_XG_n1 I1_I1942_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I146_XG_MN0 (I1_I1942_G21_14 I1_I1942_P21_18n XI1_I1942_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I146_XG_MN1 (XI1_I1942_I146_XG_n1 I1_I1942_G17_14n I1_I1942_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I149_XG_MN2 (XI1_I1942_I149_XG_n1 I1_I1942_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I149_XG_MN0 (I1_I1942_G24_17 I1_I1942_P24_21n XI1_I1942_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I149_XG_MN1 (XI1_I1942_I149_XG_n1 I1_I1942_G20_17n I1_I1942_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I197_XG_MN2 (XI1_I1942_I197_XG_n1 I1_I1942_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I197_XG_MN0 (I1_I1942_G26_0 I1_I1942_P26_11n XI1_I1942_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I197_XG_MN1 (XI1_I1942_I197_XG_n1 I1_I1942_G10_0n I1_I1942_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I84_XG_MN2 (XI1_I1988_I84_XG_n1 I1_I1988_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I84_XG_MN0 (I1_I1988_G18_17 I1_I1988_pn18 XI1_I1988_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I84_XG_MN1 (XI1_I1988_I84_XG_n1 I1_I1988_gn17 I1_I1988_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I85_XG_MN2 (XI1_I1988_I85_XG_n1 I1_I1988_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I85_XG_MN0 (I1_I1988_G19_18 I1_I1988_pn19 XI1_I1988_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I85_XG_MN1 (XI1_I1988_I85_XG_n1 I1_I1988_gn18 I1_I1988_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I146_XG_MN2 (XI1_I1988_I146_XG_n1 I1_I1988_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I146_XG_MN0 (I1_I1988_G21_14 I1_I1988_P21_18n XI1_I1988_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I146_XG_MN1 (XI1_I1988_I146_XG_n1 I1_I1988_G17_14n I1_I1988_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I198_XG_MN2 (XI1_I1988_I198_XG_n1 I1_I1988_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I198_XG_MN0 (I1_I1988_G27_0 I1_I1988_P27_12n XI1_I1988_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I198_XG_MN1 (XI1_I1988_I198_XG_n1 I1_I1988_G11_0n I1_I1988_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I149_XG_MN2 (XI1_I1988_I149_XG_n1 I1_I1988_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I149_XG_MN0 (I1_I1988_G24_17 I1_I1988_P24_21n XI1_I1988_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I149_XG_MN1 (XI1_I1988_I149_XG_n1 I1_I1988_G20_17n I1_I1988_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I197_XG_MN2 (XI1_I1988_I197_XG_n1 I1_I1988_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I197_XG_MN0 (I1_I1988_G26_0 I1_I1988_P26_11n XI1_I1988_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I197_XG_MN1 (XI1_I1988_I197_XG_n1 I1_I1988_G10_0n I1_I1988_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I82_XG_MN2 (XI1_I2066_I82_XG_n1 I1_I2066_gn16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I82_XG_MN0 (I1_I2066_G16_15 I1_I2066_pn16 XI1_I2066_I82_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I82_XG_MN1 (XI1_I2066_I82_XG_n1 I1_I2066_gn15 I1_I2066_G16_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I139_XG_MN2 (XI1_I2066_I139_XG_n1 I1_I2066_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I139_XG_MN0 (I1_I2066_G14_7 I1_I2066_P14_11n XI1_I2066_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I139_XG_MN1 (XI1_I2066_I139_XG_n1 I1_I2066_G10_7n I1_I2066_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I185_XG_MN2 (XI1_I2066_I185_XG_n1 I1_I2066_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I185_XG_MN0 (I1_I2066_G18_0 I1_I2066_P18_3n XI1_I2066_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I185_XG_MN1 (XI1_I2066_I185_XG_n1 I1_I2066_G2_0n I1_I2066_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I142_XG_MN2 (XI1_I2066_I142_XG_n1 I1_I2066_G17_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I142_XG_MN0 (I1_I2066_G17_10 I1_I2066_P17_14n XI1_I2066_I142_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I142_XG_MN1 (XI1_I2066_I142_XG_n1 I1_I2066_G13_10n I1_I2066_G17_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I138_XG_MN2 (XI1_I2066_I138_XG_n1 I1_I2066_G13_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I138_XG_MN0 (I1_I2066_G13_6 I1_I2066_P13_10n XI1_I2066_I138_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I138_XG_MN1 (XI1_I2066_I138_XG_n1 I1_I2066_G9_6n I1_I2066_G13_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I136_XG_MN2 (XI1_I2066_I136_XG_n1 I1_I2066_G11_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I136_XG_MN0 (I1_I2066_G11_4 I1_I2066_P11_8n XI1_I2066_I136_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I136_XG_MN1 (XI1_I2066_I136_XG_n1 I1_I2066_G7_4n I1_I2066_G11_4 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I132_XG_MN2 (XI1_I2066_I132_XG_n1 I1_I2066_G7_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I132_XG_MN0 (I1_I2066_G7_0 I1_I2066_P7_4n XI1_I2066_I132_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I132_XG_MN1 (XI1_I2066_I132_XG_n1 I1_I2066_G3_0n I1_I2066_G7_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I384_XG_MN2 (XI0_I1660_I384_XG_n1 I0_I1660_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I384_XG_MN0 (I0_I1660_G22_0 I0_I1660_P22_7n XI0_I1660_I384_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I384_XG_MN1 (XI0_I1660_I384_XG_n1 I0_I1660_G6_0n I0_I1660_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I405_XG_MN2 (XI0_I1660_I405_XG_n1 I0_I1660_G42_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I405_XG_MN0 (I0_I1660_G42_11 I0_I1660_P42_27n XI0_I1660_I405_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I405_XG_MN1 (XI0_I1660_I405_XG_n1 I0_I1660_G26_11n I0_I1660_G42_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I415_XG_MN2 (XI0_I1660_I415_XG_n1 I0_I1660_G52_37n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I415_XG_MN0 (I0_I1660_G52_21 I0_I1660_P52_37n XI0_I1660_I415_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I415_XG_MN1 (XI0_I1660_I415_XG_n1 I0_I1660_G36_21n I0_I1660_G52_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I419_XG_MN2 (XI0_I1660_I419_XG_n1 I0_I1660_G56_41n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I419_XG_MN0 (I0_I1660_G56_25 I0_I1660_P56_41n XI0_I1660_I419_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I419_XG_MN1 (XI0_I1660_I419_XG_n1 I0_I1660_G40_25n I0_I1660_G56_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I291_XG_MN2 (XI0_I1660_I291_XG_n1 I0_I1660_G38_35n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I291_XG_MN0 (I0_I1660_G38_31 I0_I1660_P38_35n XI0_I1660_I291_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I291_XG_MN1 (XI0_I1660_I291_XG_n1 I0_I1660_G34_31n I0_I1660_G38_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I301_XG_MN2 (XI0_I1660_I301_XG_n1 I0_I1660_G48_45n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I301_XG_MN0 (I0_I1660_G48_41 I0_I1660_P48_45n XI0_I1660_I301_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I301_XG_MN1 (XI0_I1660_I301_XG_n1 I0_I1660_G44_41n I0_I1660_G48_41 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I420_XG_MN2 (XI0_I1660_I420_XG_n1 I0_I1660_G57_42n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I420_XG_MN0 (I0_I1660_G57_26 I0_I1660_P57_42n XI0_I1660_I420_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I420_XG_MN1 (XI0_I1660_I420_XG_n1 I0_I1660_G41_26n I0_I1660_G57_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I422_XG_MN2 (XI0_I1660_I422_XG_n1 I0_I1660_G59_44n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I422_XG_MN0 (I0_I1660_G59_28 I0_I1660_P59_44n XI0_I1660_I422_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I422_XG_MN1 (XI0_I1660_I422_XG_n1 I0_I1660_G43_28n I0_I1660_G59_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I302_XG_MN2 (XI0_I1660_I302_XG_n1 I0_I1660_G49_46n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I302_XG_MN0 (I0_I1660_G49_42 I0_I1660_P49_46n XI0_I1660_I302_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I302_XG_MN1 (XI0_I1660_I302_XG_n1 I0_I1660_G45_42n I0_I1660_G49_42 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I304_XG_MN2 (XI0_I1660_I304_XG_n1 I0_I1660_G51_48n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I304_XG_MN0 (I0_I1660_G51_44 I0_I1660_P51_48n XI0_I1660_I304_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I304_XG_MN1 (XI0_I1660_I304_XG_n1 I0_I1660_G47_44n I0_I1660_G51_44 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I177_XG_MN2 (XI0_I1660_I177_XG_n1 I0_I1660_gn47 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I177_XG_MN0 (I0_I1660_G47_46 I0_I1660_pn47 XI0_I1660_I177_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I177_XG_MN1 (XI0_I1660_I177_XG_n1 I0_I1660_gn46 I0_I1660_G47_46 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I176_XG_MN2 (XI0_I1660_I176_XG_n1 I0_I1660_gn46 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I176_XG_MN0 (I0_I1660_G46_45 I0_I1660_pn46 XI0_I1660_I176_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I176_XG_MN1 (XI0_I1660_I176_XG_n1 I0_I1660_gn45 I0_I1660_G46_45 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I148_XG_MN2 (XI1_I1850_I148_XG_n1 I1_I1850_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I148_XG_MN0 (I1_I1850_G23_16 I1_I1850_P23_20n XI1_I1850_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I148_XG_MN1 (XI1_I1850_I148_XG_n1 I1_I1850_G19_16n I1_I1850_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I194_XG_MN2 (XI1_I1850_I194_XG_n1 I1_I1850_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I194_XG_MN0 (I1_I1850_G23_0 I1_I1850_P23_8n XI1_I1850_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I194_XG_MN1 (XI1_I1850_I194_XG_n1 I1_I1850_G7_0n I1_I1850_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I146_XG_MN2 (XI1_I1850_I146_XG_n1 I1_I1850_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I146_XG_MN0 (I1_I1850_G21_14 I1_I1850_P21_18n XI1_I1850_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I146_XG_MN1 (XI1_I1850_I146_XG_n1 I1_I1850_G17_14n I1_I1850_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I190_XG_MN2 (XI1_I1850_I190_XG_n1 I1_I1850_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I190_XG_MN0 (I1_I1850_G21_0 I1_I1850_P21_6n XI1_I1850_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I190_XG_MN1 (XI1_I1850_I190_XG_n1 I1_I1850_G5_0n I1_I1850_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I196_XG_MN2 (XI1_I1850_I196_XG_n1 I1_I1850_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I196_XG_MN0 (I1_I1850_G25_0 I1_I1850_P25_10n XI1_I1850_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I196_XG_MN1 (XI1_I1850_I196_XG_n1 I1_I1850_G9_0n I1_I1850_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I85_XG_MN2 (XI1_I1850_I85_XG_n1 I1_I1850_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I85_XG_MN0 (I1_I1850_G19_18 I1_I1850_pn19 XI1_I1850_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I85_XG_MN1 (XI1_I1850_I85_XG_n1 I1_I1850_gn18 I1_I1850_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I84_XG_MN2 (XI1_I1850_I84_XG_n1 I1_I1850_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I84_XG_MN0 (I1_I1850_G18_17 I1_I1850_pn18 XI1_I1850_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I84_XG_MN1 (XI1_I1850_I84_XG_n1 I1_I1850_gn17 I1_I1850_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I143_XG_MN2 (XI1_I1850_I143_XG_n1 I1_I1850_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I143_XG_MN0 (I1_I1850_G18_11 I1_I1850_P18_15n XI1_I1850_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I143_XG_MN1 (XI1_I1850_I143_XG_n1 I1_I1850_G14_11n I1_I1850_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I139_XG_MN2 (XI1_I1850_I139_XG_n1 I1_I1850_G14_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I139_XG_MN0 (I1_I1850_G14_7 I1_I1850_P14_11n XI1_I1850_I139_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I139_XG_MN1 (XI1_I1850_I139_XG_n1 I1_I1850_G10_7n I1_I1850_G14_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I84_XG_MN2 (XI1_I1896_I84_XG_n1 I1_I1896_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I84_XG_MN0 (I1_I1896_G18_17 I1_I1896_pn18 XI1_I1896_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I84_XG_MN1 (XI1_I1896_I84_XG_n1 I1_I1896_gn17 I1_I1896_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I144_XG_MN2 (XI1_I1896_I144_XG_n1 I1_I1896_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I144_XG_MN0 (I1_I1896_G19_12 I1_I1896_P19_16n XI1_I1896_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I144_XG_MN1 (XI1_I1896_I144_XG_n1 I1_I1896_G15_12n I1_I1896_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I190_XG_MN2 (XI1_I1896_I190_XG_n1 I1_I1896_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I190_XG_MN0 (I1_I1896_G21_0 I1_I1896_P21_6n XI1_I1896_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I190_XG_MN1 (XI1_I1896_I190_XG_n1 I1_I1896_G5_0n I1_I1896_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I145_XG_MN2 (XI1_I1896_I145_XG_n1 I1_I1896_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I145_XG_MN0 (I1_I1896_G20_13 I1_I1896_P20_17n XI1_I1896_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I145_XG_MN1 (XI1_I1896_I145_XG_n1 I1_I1896_G16_13n I1_I1896_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I143_XG_MN2 (XI1_I1896_I143_XG_n1 I1_I1896_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I143_XG_MN0 (I1_I1896_G18_11 I1_I1896_P18_15n XI1_I1896_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I143_XG_MN1 (XI1_I1896_I143_XG_n1 I1_I1896_G14_11n I1_I1896_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I188_XG_MN2 (XI1_I1896_I188_XG_n1 I1_I1896_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I188_XG_MN0 (I1_I1896_G20_0 I1_I1896_P20_5n XI1_I1896_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I188_XG_MN1 (XI1_I1896_I188_XG_n1 I1_I1896_G4_0n I1_I1896_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I85_XG_MN2 (XI1_I1942_I85_XG_n1 I1_I1942_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I85_XG_MN0 (I1_I1942_G19_18 I1_I1942_pn19 XI1_I1942_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I85_XG_MN1 (XI1_I1942_I85_XG_n1 I1_I1942_gn18 I1_I1942_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I150_XG_MN2 (XI1_I1942_I150_XG_n1 I1_I1942_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I150_XG_MN0 (I1_I1942_G25_18 I1_I1942_P25_22n XI1_I1942_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I150_XG_MN1 (XI1_I1942_I150_XG_n1 I1_I1942_G21_18n I1_I1942_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I198_XG_MN2 (XI1_I1942_I198_XG_n1 I1_I1942_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I198_XG_MN0 (I1_I1942_G27_0 I1_I1942_P27_12n XI1_I1942_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I198_XG_MN1 (XI1_I1942_I198_XG_n1 I1_I1942_G11_0n I1_I1942_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I192_XG_MN2 (XI1_I1942_I192_XG_n1 I1_I1942_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I192_XG_MN0 (I1_I1942_G22_0 I1_I1942_P22_7n XI1_I1942_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I192_XG_MN1 (XI1_I1942_I192_XG_n1 I1_I1942_G6_0n I1_I1942_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I87_XG_MN2 (XI1_I1988_I87_XG_n1 I1_I1988_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I87_XG_MN0 (I1_I1988_G21_20 I1_I1988_pn21 XI1_I1988_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I87_XG_MN1 (XI1_I1988_I87_XG_n1 I1_I1988_gn20 I1_I1988_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I86_XG_MN2 (XI1_I1988_I86_XG_n1 I1_I1988_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I86_XG_MN0 (I1_I1988_G20_19 I1_I1988_pn20 XI1_I1988_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I86_XG_MN1 (XI1_I1988_I86_XG_n1 I1_I1988_gn19 I1_I1988_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I150_XG_MN2 (XI1_I1988_I150_XG_n1 I1_I1988_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I150_XG_MN0 (I1_I1988_G25_18 I1_I1988_P25_22n XI1_I1988_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I150_XG_MN1 (XI1_I1988_I150_XG_n1 I1_I1988_G21_18n I1_I1988_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I147_XG_MN2 (XI1_I1988_I147_XG_n1 I1_I1988_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I147_XG_MN0 (I1_I1988_G22_15 I1_I1988_P22_19n XI1_I1988_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I147_XG_MN1 (XI1_I1988_I147_XG_n1 I1_I1988_G18_15n I1_I1988_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I192_XG_MN2 (XI1_I1988_I192_XG_n1 I1_I1988_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I192_XG_MN0 (I1_I1988_G22_0 I1_I1988_P22_7n XI1_I1988_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I192_XG_MN1 (XI1_I1988_I192_XG_n1 I1_I1988_G6_0n I1_I1988_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I83_XG_MN2 (XI1_I2066_I83_XG_n1 I1_I2066_gn17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I83_XG_MN0 (I1_I2066_G17_16 I1_I2066_pn17 XI1_I2066_I83_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I83_XG_MN1 (XI1_I2066_I83_XG_n1 I1_I2066_gn16 I1_I2066_G17_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I84_XG_MN2 (XI1_I2066_I84_XG_n1 I1_I2066_gn18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I84_XG_MN0 (I1_I2066_G18_17 I1_I2066_pn18 XI1_I2066_I84_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I84_XG_MN1 (XI1_I2066_I84_XG_n1 I1_I2066_gn17 I1_I2066_G18_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I143_XG_MN2 (XI1_I2066_I143_XG_n1 I1_I2066_G18_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I143_XG_MN0 (I1_I2066_G18_11 I1_I2066_P18_15n XI1_I2066_I143_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I143_XG_MN1 (XI1_I2066_I143_XG_n1 I1_I2066_G14_11n I1_I2066_G18_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I196_XG_MN2 (XI1_I2066_I196_XG_n1 I1_I2066_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I196_XG_MN0 (I1_I2066_G25_0 I1_I2066_P25_10n XI1_I2066_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I196_XG_MN1 (XI1_I2066_I196_XG_n1 I1_I2066_G9_0n I1_I2066_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I401_XG_MN2 (XI0_I1660_I401_XG_n1 I0_I1660_G38_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I401_XG_MN0 (I0_I1660_G38_7 I0_I1660_P38_23n XI0_I1660_I401_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I401_XG_MN1 (XI0_I1660_I401_XG_n1 I0_I1660_G22_7n I0_I1660_G38_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I413_XG_MN2 (XI0_I1660_I413_XG_n1 I0_I1660_G50_35n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I413_XG_MN0 (I0_I1660_G50_19 I0_I1660_P50_35n XI0_I1660_I413_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I413_XG_MN1 (XI0_I1660_I413_XG_n1 I0_I1660_G34_19n I0_I1660_G50_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I393_XG_MN2 (XI0_I1660_I393_XG_n1 I0_I1660_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I393_XG_MN0 (I0_I1660_G30_0 I0_I1660_P30_15n XI0_I1660_I393_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I393_XG_MN1 (XI0_I1660_I393_XG_n1 I0_I1660_G14_0n I0_I1660_G30_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I295_XG_MN2 (XI0_I1660_I295_XG_n1 I0_I1660_G42_39n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I295_XG_MN0 (I0_I1660_G42_35 I0_I1660_P42_39n XI0_I1660_I295_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I295_XG_MN1 (XI0_I1660_I295_XG_n1 I0_I1660_G38_35n I0_I1660_G42_35 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I423_XG_MN2 (XI0_I1660_I423_XG_n1 I0_I1660_G60_45n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I423_XG_MN0 (I0_I1660_G60_29 I0_I1660_P60_45n XI0_I1660_I423_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I423_XG_MN1 (XI0_I1660_I423_XG_n1 I0_I1660_G44_29n I0_I1660_G60_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I424_XG_MN2 (XI0_I1660_I424_XG_n1 I0_I1660_G61_46n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I424_XG_MN0 (I0_I1660_G61_30 I0_I1660_P61_46n XI0_I1660_I424_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I424_XG_MN1 (XI0_I1660_I424_XG_n1 I0_I1660_G45_30n I0_I1660_G61_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I306_XG_MN2 (XI0_I1660_I306_XG_n1 I0_I1660_G53_50n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I306_XG_MN0 (I0_I1660_G53_46 I0_I1660_P53_50n XI0_I1660_I306_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I306_XG_MN1 (XI0_I1660_I306_XG_n1 I0_I1660_G49_46n I0_I1660_G53_46 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I178_XG_MN2 (XI0_I1660_I178_XG_n1 I0_I1660_gn48 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I178_XG_MN0 (I0_I1660_G48_47 I0_I1660_pn48 XI0_I1660_I178_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I178_XG_MN1 (XI0_I1660_I178_XG_n1 I0_I1660_gn47 I0_I1660_G48_47 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I198_XG_MN2 (XI1_I1850_I198_XG_n1 I1_I1850_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I198_XG_MN0 (I1_I1850_G27_0 I1_I1850_P27_12n XI1_I1850_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I198_XG_MN1 (XI1_I1850_I198_XG_n1 I1_I1850_G11_0n I1_I1850_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I150_XG_MN2 (XI1_I1850_I150_XG_n1 I1_I1850_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I150_XG_MN0 (I1_I1850_G25_18 I1_I1850_P25_22n XI1_I1850_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I150_XG_MN1 (XI1_I1850_I150_XG_n1 I1_I1850_G21_18n I1_I1850_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I86_XG_MN2 (XI1_I1850_I86_XG_n1 I1_I1850_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I86_XG_MN0 (I1_I1850_G20_19 I1_I1850_pn20 XI1_I1850_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I86_XG_MN1 (XI1_I1850_I86_XG_n1 I1_I1850_gn19 I1_I1850_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I188_XG_MN2 (XI1_I1850_I188_XG_n1 I1_I1850_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I188_XG_MN0 (I1_I1850_G20_0 I1_I1850_P20_5n XI1_I1850_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I188_XG_MN1 (XI1_I1850_I188_XG_n1 I1_I1850_G4_0n I1_I1850_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I185_XG_MN2 (XI1_I1850_I185_XG_n1 I1_I1850_G18_3n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I185_XG_MN0 (I1_I1850_G18_0 I1_I1850_P18_3n XI1_I1850_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I185_XG_MN1 (XI1_I1850_I185_XG_n1 I1_I1850_G2_0n I1_I1850_G18_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I86_XG_MN2 (XI1_I1896_I86_XG_n1 I1_I1896_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I86_XG_MN0 (I1_I1896_G20_19 I1_I1896_pn20 XI1_I1896_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I86_XG_MN1 (XI1_I1896_I86_XG_n1 I1_I1896_gn19 I1_I1896_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I85_XG_MN2 (XI1_I1896_I85_XG_n1 I1_I1896_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I85_XG_MN0 (I1_I1896_G19_18 I1_I1896_pn19 XI1_I1896_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I85_XG_MN1 (XI1_I1896_I85_XG_n1 I1_I1896_gn18 I1_I1896_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I146_XG_MN2 (XI1_I1896_I146_XG_n1 I1_I1896_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I146_XG_MN0 (I1_I1896_G21_14 I1_I1896_P21_18n XI1_I1896_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I146_XG_MN1 (XI1_I1896_I146_XG_n1 I1_I1896_G17_14n I1_I1896_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I196_XG_MN2 (XI1_I1896_I196_XG_n1 I1_I1896_G25_10n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I196_XG_MN0 (I1_I1896_G25_0 I1_I1896_P25_10n XI1_I1896_I196_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I196_XG_MN1 (XI1_I1896_I196_XG_n1 I1_I1896_G9_0n I1_I1896_G25_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I149_XG_MN2 (XI1_I1896_I149_XG_n1 I1_I1896_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I149_XG_MN0 (I1_I1896_G24_17 I1_I1896_P24_21n XI1_I1896_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I149_XG_MN1 (XI1_I1896_I149_XG_n1 I1_I1896_G20_17n I1_I1896_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I195_XG_MN2 (XI1_I1896_I195_XG_n1 I1_I1896_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I195_XG_MN0 (I1_I1896_G24_0 I1_I1896_P24_9n XI1_I1896_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I195_XG_MN1 (XI1_I1896_I195_XG_n1 I1_I1896_G8_0n I1_I1896_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I87_XG_MN2 (XI1_I1942_I87_XG_n1 I1_I1942_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I87_XG_MN0 (I1_I1942_G21_20 I1_I1942_pn21 XI1_I1942_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I87_XG_MN1 (XI1_I1942_I87_XG_n1 I1_I1942_gn20 I1_I1942_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I86_XG_MN2 (XI1_I1942_I86_XG_n1 I1_I1942_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I86_XG_MN0 (I1_I1942_G20_19 I1_I1942_pn20 XI1_I1942_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I86_XG_MN1 (XI1_I1942_I86_XG_n1 I1_I1942_gn19 I1_I1942_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I148_XG_MN2 (XI1_I1942_I148_XG_n1 I1_I1942_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I148_XG_MN0 (I1_I1942_G23_16 I1_I1942_P23_20n XI1_I1942_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I148_XG_MN1 (XI1_I1942_I148_XG_n1 I1_I1942_G19_16n I1_I1942_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I194_XG_MN2 (XI1_I1942_I194_XG_n1 I1_I1942_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I194_XG_MN0 (I1_I1942_G23_0 I1_I1942_P23_8n XI1_I1942_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I194_XG_MN1 (XI1_I1942_I194_XG_n1 I1_I1942_G7_0n I1_I1942_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I147_XG_MN2 (XI1_I1942_I147_XG_n1 I1_I1942_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I147_XG_MN0 (I1_I1942_G22_15 I1_I1942_P22_19n XI1_I1942_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I147_XG_MN1 (XI1_I1942_I147_XG_n1 I1_I1942_G18_15n I1_I1942_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I151_XG_MN2 (XI1_I1942_I151_XG_n1 I1_I1942_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I151_XG_MN0 (I1_I1942_G26_19 I1_I1942_P26_23n XI1_I1942_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I151_XG_MN1 (XI1_I1942_I151_XG_n1 I1_I1942_G22_19n I1_I1942_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I199_XG_MN2 (XI1_I1942_I199_XG_n1 I1_I1942_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I199_XG_MN0 (I1_I1942_G28_0 I1_I1942_P28_13n XI1_I1942_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I199_XG_MN1 (XI1_I1942_I199_XG_n1 I1_I1942_G12_0n I1_I1942_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I88_XG_MN2 (XI1_I1988_I88_XG_n1 I1_I1988_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I88_XG_MN0 (I1_I1988_G22_21 I1_I1988_pn22 XI1_I1988_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I88_XG_MN1 (XI1_I1988_I88_XG_n1 I1_I1988_gn21 I1_I1988_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I148_XG_MN2 (XI1_I1988_I148_XG_n1 I1_I1988_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I148_XG_MN0 (I1_I1988_G23_16 I1_I1988_P23_20n XI1_I1988_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I148_XG_MN1 (XI1_I1988_I148_XG_n1 I1_I1988_G19_16n I1_I1988_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I152_XG_MN2 (XI1_I1988_I152_XG_n1 I1_I1988_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I152_XG_MN0 (I1_I1988_G27_20 I1_I1988_P27_24n XI1_I1988_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I152_XG_MN1 (XI1_I1988_I152_XG_n1 I1_I1988_G23_20n I1_I1988_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I194_XG_MN2 (XI1_I1988_I194_XG_n1 I1_I1988_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I194_XG_MN0 (I1_I1988_G23_0 I1_I1988_P23_8n XI1_I1988_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I194_XG_MN1 (XI1_I1988_I194_XG_n1 I1_I1988_G7_0n I1_I1988_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I151_XG_MN2 (XI1_I1988_I151_XG_n1 I1_I1988_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I151_XG_MN0 (I1_I1988_G26_19 I1_I1988_P26_23n XI1_I1988_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I151_XG_MN1 (XI1_I1988_I151_XG_n1 I1_I1988_G22_19n I1_I1988_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I199_XG_MN2 (XI1_I1988_I199_XG_n1 I1_I1988_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I199_XG_MN0 (I1_I1988_G28_0 I1_I1988_P28_13n XI1_I1988_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I199_XG_MN1 (XI1_I1988_I199_XG_n1 I1_I1988_G12_0n I1_I1988_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I85_XG_MN2 (XI1_I2066_I85_XG_n1 I1_I2066_gn19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I85_XG_MN0 (I1_I2066_G19_18 I1_I2066_pn19 XI1_I2066_I85_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I85_XG_MN1 (XI1_I2066_I85_XG_n1 I1_I2066_gn18 I1_I2066_G19_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I149_XG_MN2 (XI1_I2066_I149_XG_n1 I1_I2066_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I149_XG_MN0 (I1_I2066_G24_17 I1_I2066_P24_21n XI1_I2066_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I149_XG_MN1 (XI1_I2066_I149_XG_n1 I1_I2066_G20_17n I1_I2066_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I145_XG_MN2 (XI1_I2066_I145_XG_n1 I1_I2066_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I145_XG_MN0 (I1_I2066_G20_13 I1_I2066_P20_17n XI1_I2066_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I145_XG_MN1 (XI1_I2066_I145_XG_n1 I1_I2066_G16_13n I1_I2066_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I199_XG_MN2 (XI1_I2066_I199_XG_n1 I1_I2066_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I199_XG_MN0 (I1_I2066_G28_0 I1_I2066_P28_13n XI1_I2066_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I199_XG_MN1 (XI1_I2066_I199_XG_n1 I1_I2066_G12_0n I1_I2066_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I188_XG_MN2 (XI1_I2066_I188_XG_n1 I1_I2066_G20_5n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I188_XG_MN0 (I1_I2066_G20_0 I1_I2066_P20_5n XI1_I2066_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I188_XG_MN1 (XI1_I2066_I188_XG_n1 I1_I2066_G4_0n I1_I2066_G20_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I144_XG_MN2 (XI1_I2066_I144_XG_n1 I1_I2066_G19_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I144_XG_MN0 (I1_I2066_G19_12 I1_I2066_P19_16n XI1_I2066_I144_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I144_XG_MN1 (XI1_I2066_I144_XG_n1 I1_I2066_G15_12n I1_I2066_G19_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I140_XG_MN2 (XI1_I2066_I140_XG_n1 I1_I2066_G15_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I140_XG_MN0 (I1_I2066_G15_8 I1_I2066_P15_12n XI1_I2066_I140_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I140_XG_MN1 (XI1_I2066_I140_XG_n1 I1_I2066_G11_8n I1_I2066_G15_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I186_XG_MN2 (XI1_I2066_I186_XG_n1 I1_I2066_G19_4n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I186_XG_MN0 (I1_I2066_G19_0 I1_I2066_P19_4n XI1_I2066_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I186_XG_MN1 (XI1_I2066_I186_XG_n1 I1_I2066_G3_0n I1_I2066_G19_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I409_XG_MN2 (XI0_I1660_I409_XG_n1 I0_I1660_G46_31n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I409_XG_MN0 (I0_I1660_G46_15 I0_I1660_P46_31n XI0_I1660_I409_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I409_XG_MN1 (XI0_I1660_I409_XG_n1 I0_I1660_G30_15n I0_I1660_G46_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I299_XG_MN2 (XI0_I1660_I299_XG_n1 I0_I1660_G46_43n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I299_XG_MN0 (I0_I1660_G46_39 I0_I1660_P46_43n XI0_I1660_I299_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I299_XG_MN1 (XI0_I1660_I299_XG_n1 I0_I1660_G42_39n I0_I1660_G46_39 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I303_XG_MN2 (XI0_I1660_I303_XG_n1 I0_I1660_G50_47n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I303_XG_MN0 (I0_I1660_G50_43 I0_I1660_P50_47n XI0_I1660_I303_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I303_XG_MN1 (XI0_I1660_I303_XG_n1 I0_I1660_G46_43n I0_I1660_G50_43 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I305_XG_MN2 (XI0_I1660_I305_XG_n1 I0_I1660_G52_49n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I305_XG_MN0 (I0_I1660_G52_45 I0_I1660_P52_49n XI0_I1660_I305_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I305_XG_MN1 (XI0_I1660_I305_XG_n1 I0_I1660_G48_45n I0_I1660_G52_45 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I310_XG_MN2 (XI0_I1660_I310_XG_n1 I0_I1660_G57_54n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I310_XG_MN0 (I0_I1660_G57_50 I0_I1660_P57_54n XI0_I1660_I310_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I310_XG_MN1 (XI0_I1660_I310_XG_n1 I0_I1660_G53_50n I0_I1660_G57_50 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I316_XG_MN2 (XI0_I1660_I316_XG_n1 I0_I1660_G63_60n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I316_XG_MN0 (I0_I1660_G63_56 I0_I1660_P63_60n XI0_I1660_I316_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I316_XG_MN1 (XI0_I1660_I316_XG_n1 I0_I1660_G59_56n I0_I1660_G63_56 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I312_XG_MN2 (XI0_I1660_I312_XG_n1 I0_I1660_G59_56n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I312_XG_MN0 (I0_I1660_G59_52 I0_I1660_P59_56n XI0_I1660_I312_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I312_XG_MN1 (XI0_I1660_I312_XG_n1 I0_I1660_G55_52n I0_I1660_G59_52 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I308_XG_MN2 (XI0_I1660_I308_XG_n1 I0_I1660_G55_52n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I308_XG_MN0 (I0_I1660_G55_48 I0_I1660_P55_52n XI0_I1660_I308_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I308_XG_MN1 (XI0_I1660_I308_XG_n1 I0_I1660_G51_48n I0_I1660_G55_48 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I179_XG_MN2 (XI0_I1660_I179_XG_n1 I0_I1660_gn49 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I179_XG_MN0 (I0_I1660_G49_48 I0_I1660_pn49 XI0_I1660_I179_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I179_XG_MN1 (XI0_I1660_I179_XG_n1 I0_I1660_gn48 I0_I1660_G49_48 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I156_XG_MN2 (XI1_I1850_I156_XG_n1 I1_I1850_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I156_XG_MN0 (I1_I1850_G31_24 I1_I1850_P31_28n XI1_I1850_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I156_XG_MN1 (XI1_I1850_I156_XG_n1 I1_I1850_G27_24n I1_I1850_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I152_XG_MN2 (XI1_I1850_I152_XG_n1 I1_I1850_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I152_XG_MN0 (I1_I1850_G27_20 I1_I1850_P27_24n XI1_I1850_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I152_XG_MN1 (XI1_I1850_I152_XG_n1 I1_I1850_G23_20n I1_I1850_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I200_XG_MN2 (XI1_I1850_I200_XG_n1 I1_I1850_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I200_XG_MN0 (I1_I1850_G29_0 I1_I1850_P29_14n XI1_I1850_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I200_XG_MN1 (XI1_I1850_I200_XG_n1 I1_I1850_G13_0n I1_I1850_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I87_XG_MN2 (XI1_I1850_I87_XG_n1 I1_I1850_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I87_XG_MN0 (I1_I1850_G21_20 I1_I1850_pn21 XI1_I1850_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I87_XG_MN1 (XI1_I1850_I87_XG_n1 I1_I1850_gn20 I1_I1850_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I149_XG_MN2 (XI1_I1850_I149_XG_n1 I1_I1850_G24_21n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I149_XG_MN0 (I1_I1850_G24_17 I1_I1850_P24_21n XI1_I1850_I149_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I149_XG_MN1 (XI1_I1850_I149_XG_n1 I1_I1850_G20_17n I1_I1850_G24_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I145_XG_MN2 (XI1_I1850_I145_XG_n1 I1_I1850_G20_17n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I145_XG_MN0 (I1_I1850_G20_13 I1_I1850_P20_17n XI1_I1850_I145_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I145_XG_MN1 (XI1_I1850_I145_XG_n1 I1_I1850_G16_13n I1_I1850_G20_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I195_XG_MN2 (XI1_I1850_I195_XG_n1 I1_I1850_G24_9n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I195_XG_MN0 (I1_I1850_G24_0 I1_I1850_P24_9n XI1_I1850_I195_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I195_XG_MN1 (XI1_I1850_I195_XG_n1 I1_I1850_G8_0n I1_I1850_G24_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I87_XG_MN2 (XI1_I1896_I87_XG_n1 I1_I1896_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I87_XG_MN0 (I1_I1896_G21_20 I1_I1896_pn21 XI1_I1896_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I87_XG_MN1 (XI1_I1896_I87_XG_n1 I1_I1896_gn20 I1_I1896_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I150_XG_MN2 (XI1_I1896_I150_XG_n1 I1_I1896_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I150_XG_MN0 (I1_I1896_G25_18 I1_I1896_P25_22n XI1_I1896_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I150_XG_MN1 (XI1_I1896_I150_XG_n1 I1_I1896_G21_18n I1_I1896_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I198_XG_MN2 (XI1_I1896_I198_XG_n1 I1_I1896_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I198_XG_MN0 (I1_I1896_G27_0 I1_I1896_P27_12n XI1_I1896_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I198_XG_MN1 (XI1_I1896_I198_XG_n1 I1_I1896_G11_0n I1_I1896_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I197_XG_MN2 (XI1_I1896_I197_XG_n1 I1_I1896_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I197_XG_MN0 (I1_I1896_G26_0 I1_I1896_P26_11n XI1_I1896_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I197_XG_MN1 (XI1_I1896_I197_XG_n1 I1_I1896_G10_0n I1_I1896_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I88_XG_MN2 (XI1_I1942_I88_XG_n1 I1_I1942_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I88_XG_MN0 (I1_I1942_G22_21 I1_I1942_pn22 XI1_I1942_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I88_XG_MN1 (XI1_I1942_I88_XG_n1 I1_I1942_gn21 I1_I1942_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I89_XG_MN2 (XI1_I1942_I89_XG_n1 I1_I1942_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I89_XG_MN0 (I1_I1942_G23_22 I1_I1942_pn23 XI1_I1942_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I89_XG_MN1 (XI1_I1942_I89_XG_n1 I1_I1942_gn22 I1_I1942_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I152_XG_MN2 (XI1_I1942_I152_XG_n1 I1_I1942_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I152_XG_MN0 (I1_I1942_G27_20 I1_I1942_P27_24n XI1_I1942_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I152_XG_MN1 (XI1_I1942_I152_XG_n1 I1_I1942_G23_20n I1_I1942_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I200_XG_MN2 (XI1_I1942_I200_XG_n1 I1_I1942_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I200_XG_MN0 (I1_I1942_G29_0 I1_I1942_P29_14n XI1_I1942_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I200_XG_MN1 (XI1_I1942_I200_XG_n1 I1_I1942_G13_0n I1_I1942_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I153_XG_MN2 (XI1_I1942_I153_XG_n1 I1_I1942_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I153_XG_MN0 (I1_I1942_G28_21 I1_I1942_P28_25n XI1_I1942_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I153_XG_MN1 (XI1_I1942_I153_XG_n1 I1_I1942_G24_21n I1_I1942_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I89_XG_MN2 (XI1_I1988_I89_XG_n1 I1_I1988_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I89_XG_MN0 (I1_I1988_G23_22 I1_I1988_pn23 XI1_I1988_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I89_XG_MN1 (XI1_I1988_I89_XG_n1 I1_I1988_gn22 I1_I1988_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I90_XG_MN2 (XI1_I1988_I90_XG_n1 I1_I1988_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I90_XG_MN0 (I1_I1988_G24_23 I1_I1988_pn24 XI1_I1988_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I90_XG_MN1 (XI1_I1988_I90_XG_n1 I1_I1988_gn23 I1_I1988_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I154_XG_MN2 (XI1_I1988_I154_XG_n1 I1_I1988_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I154_XG_MN0 (I1_I1988_G29_22 I1_I1988_P29_26n XI1_I1988_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I154_XG_MN1 (XI1_I1988_I154_XG_n1 I1_I1988_G25_22n I1_I1988_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I200_XG_MN2 (XI1_I1988_I200_XG_n1 I1_I1988_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I200_XG_MN0 (I1_I1988_G29_0 I1_I1988_P29_14n XI1_I1988_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I200_XG_MN1 (XI1_I1988_I200_XG_n1 I1_I1988_G13_0n I1_I1988_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I153_XG_MN2 (XI1_I1988_I153_XG_n1 I1_I1988_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I153_XG_MN0 (I1_I1988_G28_21 I1_I1988_P28_25n XI1_I1988_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I153_XG_MN1 (XI1_I1988_I153_XG_n1 I1_I1988_G24_21n I1_I1988_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I86_XG_MN2 (XI1_I2066_I86_XG_n1 I1_I2066_gn20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I86_XG_MN0 (I1_I2066_G20_19 I1_I2066_pn20 XI1_I2066_I86_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I86_XG_MN1 (XI1_I2066_I86_XG_n1 I1_I2066_gn19 I1_I2066_G20_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I87_XG_MN2 (XI1_I2066_I87_XG_n1 I1_I2066_gn21 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I87_XG_MN0 (I1_I2066_G21_20 I1_I2066_pn21 XI1_I2066_I87_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I87_XG_MN1 (XI1_I2066_I87_XG_n1 I1_I2066_gn20 I1_I2066_G21_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I197_XG_MN2 (XI1_I2066_I197_XG_n1 I1_I2066_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I197_XG_MN0 (I1_I2066_G26_0 I1_I2066_P26_11n XI1_I2066_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I197_XG_MN1 (XI1_I2066_I197_XG_n1 I1_I2066_G10_0n I1_I2066_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I150_XG_MN2 (XI1_I2066_I150_XG_n1 I1_I2066_G25_22n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I150_XG_MN0 (I1_I2066_G25_18 I1_I2066_P25_22n XI1_I2066_I150_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I150_XG_MN1 (XI1_I2066_I150_XG_n1 I1_I2066_G21_18n I1_I2066_G25_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I146_XG_MN2 (XI1_I2066_I146_XG_n1 I1_I2066_G21_18n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I146_XG_MN0 (I1_I2066_G21_14 I1_I2066_P21_18n XI1_I2066_I146_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I146_XG_MN1 (XI1_I2066_I146_XG_n1 I1_I2066_G17_14n I1_I2066_G21_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I190_XG_MN2 (XI1_I2066_I190_XG_n1 I1_I2066_G21_6n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I190_XG_MN0 (I1_I2066_G21_0 I1_I2066_P21_6n XI1_I2066_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I190_XG_MN1 (XI1_I2066_I190_XG_n1 I1_I2066_G5_0n I1_I2066_G21_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I417_XG_MN2 (XI0_I1660_I417_XG_n1 I0_I1660_G54_39n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I417_XG_MN0 (I0_I1660_G54_23 I0_I1660_P54_39n XI0_I1660_I417_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I417_XG_MN1 (XI0_I1660_I417_XG_n1 I0_I1660_G38_23n I0_I1660_G54_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I421_XG_MN2 (XI0_I1660_I421_XG_n1 I0_I1660_G58_43n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I421_XG_MN0 (I0_I1660_G58_27 I0_I1660_P58_43n XI0_I1660_I421_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I421_XG_MN1 (XI0_I1660_I421_XG_n1 I0_I1660_G42_27n I0_I1660_G58_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I309_XG_MN2 (XI0_I1660_I309_XG_n1 I0_I1660_G56_53n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I309_XG_MN0 (I0_I1660_G56_49 I0_I1660_P56_53n XI0_I1660_I309_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I309_XG_MN1 (XI0_I1660_I309_XG_n1 I0_I1660_G52_49n I0_I1660_G56_49 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I314_XG_MN2 (XI0_I1660_I314_XG_n1 I0_I1660_G61_58n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I314_XG_MN0 (I0_I1660_G61_54 I0_I1660_P61_58n XI0_I1660_I314_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I314_XG_MN1 (XI0_I1660_I314_XG_n1 I0_I1660_G57_54n I0_I1660_G61_54 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I180_XG_MN2 (XI0_I1660_I180_XG_n1 I0_I1660_gn50 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I180_XG_MN0 (I0_I1660_G50_49 I0_I1660_pn50 XI0_I1660_I180_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I180_XG_MN1 (XI0_I1660_I180_XG_n1 I0_I1660_gn49 I0_I1660_G50_49 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I154_XG_MN2 (XI1_I1850_I154_XG_n1 I1_I1850_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I154_XG_MN0 (I1_I1850_G29_22 I1_I1850_P29_26n XI1_I1850_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I154_XG_MN1 (XI1_I1850_I154_XG_n1 I1_I1850_G25_22n I1_I1850_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I89_XG_MN2 (XI1_I1850_I89_XG_n1 I1_I1850_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I89_XG_MN0 (I1_I1850_G23_22 I1_I1850_pn23 XI1_I1850_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I89_XG_MN1 (XI1_I1850_I89_XG_n1 I1_I1850_gn22 I1_I1850_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I91_XG_MN2 (XI1_I1850_I91_XG_n1 I1_I1850_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I91_XG_MN0 (I1_I1850_G25_24 I1_I1850_pn25 XI1_I1850_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I91_XG_MN1 (XI1_I1850_I91_XG_n1 I1_I1850_gn24 I1_I1850_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I90_XG_MN2 (XI1_I1850_I90_XG_n1 I1_I1850_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I90_XG_MN0 (I1_I1850_G24_23 I1_I1850_pn24 XI1_I1850_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I90_XG_MN1 (XI1_I1850_I90_XG_n1 I1_I1850_gn23 I1_I1850_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I88_XG_MN2 (XI1_I1850_I88_XG_n1 I1_I1850_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I88_XG_MN0 (I1_I1850_G22_21 I1_I1850_pn22 XI1_I1850_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I88_XG_MN1 (XI1_I1850_I88_XG_n1 I1_I1850_gn21 I1_I1850_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I147_XG_MN2 (XI1_I1850_I147_XG_n1 I1_I1850_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I147_XG_MN0 (I1_I1850_G22_15 I1_I1850_P22_19n XI1_I1850_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I147_XG_MN1 (XI1_I1850_I147_XG_n1 I1_I1850_G18_15n I1_I1850_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I197_XG_MN2 (XI1_I1850_I197_XG_n1 I1_I1850_G26_11n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I197_XG_MN0 (I1_I1850_G26_0 I1_I1850_P26_11n XI1_I1850_I197_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I197_XG_MN1 (XI1_I1850_I197_XG_n1 I1_I1850_G10_0n I1_I1850_G26_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I192_XG_MN2 (XI1_I1850_I192_XG_n1 I1_I1850_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I192_XG_MN0 (I1_I1850_G22_0 I1_I1850_P22_7n XI1_I1850_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I192_XG_MN1 (XI1_I1850_I192_XG_n1 I1_I1850_G6_0n I1_I1850_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I89_XG_MN2 (XI1_I1896_I89_XG_n1 I1_I1896_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I89_XG_MN0 (I1_I1896_G23_22 I1_I1896_pn23 XI1_I1896_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I89_XG_MN1 (XI1_I1896_I89_XG_n1 I1_I1896_gn22 I1_I1896_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I88_XG_MN2 (XI1_I1896_I88_XG_n1 I1_I1896_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I88_XG_MN0 (I1_I1896_G22_21 I1_I1896_pn22 XI1_I1896_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I88_XG_MN1 (XI1_I1896_I88_XG_n1 I1_I1896_gn21 I1_I1896_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I148_XG_MN2 (XI1_I1896_I148_XG_n1 I1_I1896_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I148_XG_MN0 (I1_I1896_G23_16 I1_I1896_P23_20n XI1_I1896_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I148_XG_MN1 (XI1_I1896_I148_XG_n1 I1_I1896_G19_16n I1_I1896_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I152_XG_MN2 (XI1_I1896_I152_XG_n1 I1_I1896_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I152_XG_MN0 (I1_I1896_G27_20 I1_I1896_P27_24n XI1_I1896_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I152_XG_MN1 (XI1_I1896_I152_XG_n1 I1_I1896_G23_20n I1_I1896_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I194_XG_MN2 (XI1_I1896_I194_XG_n1 I1_I1896_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I194_XG_MN0 (I1_I1896_G23_0 I1_I1896_P23_8n XI1_I1896_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I194_XG_MN1 (XI1_I1896_I194_XG_n1 I1_I1896_G7_0n I1_I1896_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I192_XG_MN2 (XI1_I1896_I192_XG_n1 I1_I1896_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I192_XG_MN0 (I1_I1896_G22_0 I1_I1896_P22_7n XI1_I1896_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I192_XG_MN1 (XI1_I1896_I192_XG_n1 I1_I1896_G6_0n I1_I1896_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I91_XG_MN2 (XI1_I1942_I91_XG_n1 I1_I1942_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I91_XG_MN0 (I1_I1942_G25_24 I1_I1942_pn25 XI1_I1942_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I91_XG_MN1 (XI1_I1942_I91_XG_n1 I1_I1942_gn24 I1_I1942_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I90_XG_MN2 (XI1_I1942_I90_XG_n1 I1_I1942_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I90_XG_MN0 (I1_I1942_G24_23 I1_I1942_pn24 XI1_I1942_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I90_XG_MN1 (XI1_I1942_I90_XG_n1 I1_I1942_gn23 I1_I1942_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I154_XG_MN2 (XI1_I1942_I154_XG_n1 I1_I1942_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I154_XG_MN0 (I1_I1942_G29_22 I1_I1942_P29_26n XI1_I1942_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I154_XG_MN1 (XI1_I1942_I154_XG_n1 I1_I1942_G25_22n I1_I1942_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I202_XG_MN2 (XI1_I1942_I202_XG_n1 I1_I1942_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I202_XG_MN0 (I1_c30_o I1_I1942_P31_16n XI1_I1942_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I202_XG_MN1 (XI1_I1942_I202_XG_n1 I1_I1942_G15_0n I1_c30_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I155_XG_MN2 (XI1_I1942_I155_XG_n1 I1_I1942_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I155_XG_MN0 (I1_I1942_G30_23 I1_I1942_P30_27n XI1_I1942_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I155_XG_MN1 (XI1_I1942_I155_XG_n1 I1_I1942_G26_23n I1_I1942_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I201_XG_MN2 (XI1_I1942_I201_XG_n1 I1_I1942_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I201_XG_MN0 (I1_c30_m I1_I1942_P30_15n XI1_I1942_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I201_XG_MN1 (XI1_I1942_I201_XG_n1 I1_I1942_G14_0n I1_c30_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I91_XG_MN2 (XI1_I1988_I91_XG_n1 I1_I1988_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I91_XG_MN0 (I1_I1988_G25_24 I1_I1988_pn25 XI1_I1988_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I91_XG_MN1 (XI1_I1988_I91_XG_n1 I1_I1988_gn24 I1_I1988_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I202_XG_MN2 (XI1_I1988_I202_XG_n1 I1_I1988_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I202_XG_MN0 (I1_c31_o I1_I1988_P31_16n XI1_I1988_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I202_XG_MN1 (XI1_I1988_I202_XG_n1 I1_I1988_G15_0n I1_c31_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I155_XG_MN2 (XI1_I1988_I155_XG_n1 I1_I1988_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I155_XG_MN0 (I1_I1988_G30_23 I1_I1988_P30_27n XI1_I1988_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I155_XG_MN1 (XI1_I1988_I155_XG_n1 I1_I1988_G26_23n I1_I1988_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I201_XG_MN2 (XI1_I1988_I201_XG_n1 I1_I1988_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I201_XG_MN0 (I1_c31_m I1_I1988_P30_15n XI1_I1988_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I201_XG_MN1 (XI1_I1988_I201_XG_n1 I1_I1988_G14_0n I1_c31_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I89_XG_MN2 (XI1_I2066_I89_XG_n1 I1_I2066_gn23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I89_XG_MN0 (I1_I2066_G23_22 I1_I2066_pn23 XI1_I2066_I89_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I89_XG_MN1 (XI1_I2066_I89_XG_n1 I1_I2066_gn22 I1_I2066_G23_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I88_XG_MN2 (XI1_I2066_I88_XG_n1 I1_I2066_gn22 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I88_XG_MN0 (I1_I2066_G22_21 I1_I2066_pn22 XI1_I2066_I88_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I88_XG_MN1 (XI1_I2066_I88_XG_n1 I1_I2066_gn21 I1_I2066_G22_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I153_XG_MN2 (XI1_I2066_I153_XG_n1 I1_I2066_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I153_XG_MN0 (I1_I2066_G28_21 I1_I2066_P28_25n XI1_I2066_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I153_XG_MN1 (XI1_I2066_I153_XG_n1 I1_I2066_G24_21n I1_I2066_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I151_XG_MN2 (XI1_I2066_I151_XG_n1 I1_I2066_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I151_XG_MN0 (I1_I2066_G26_19 I1_I2066_P26_23n XI1_I2066_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I151_XG_MN1 (XI1_I2066_I151_XG_n1 I1_I2066_G22_19n I1_I2066_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I147_XG_MN2 (XI1_I2066_I147_XG_n1 I1_I2066_G22_19n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I147_XG_MN0 (I1_I2066_G22_15 I1_I2066_P22_19n XI1_I2066_I147_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I147_XG_MN1 (XI1_I2066_I147_XG_n1 I1_I2066_G18_15n I1_I2066_G22_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I192_XG_MN2 (XI1_I2066_I192_XG_n1 I1_I2066_G22_7n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I192_XG_MN0 (I1_I2066_G22_0 I1_I2066_P22_7n XI1_I2066_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I192_XG_MN1 (XI1_I2066_I192_XG_n1 I1_I2066_G6_0n I1_I2066_G22_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I148_XG_MN2 (XI1_I2066_I148_XG_n1 I1_I2066_G23_20n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I148_XG_MN0 (I1_I2066_G23_16 I1_I2066_P23_20n XI1_I2066_I148_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I148_XG_MN1 (XI1_I2066_I148_XG_n1 I1_I2066_G19_16n I1_I2066_G23_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I152_XG_MN2 (XI1_I2066_I152_XG_n1 I1_I2066_G27_24n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I152_XG_MN0 (I1_I2066_G27_20 I1_I2066_P27_24n XI1_I2066_I152_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I152_XG_MN1 (XI1_I2066_I152_XG_n1 I1_I2066_G23_20n I1_I2066_G27_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I198_XG_MN2 (XI1_I2066_I198_XG_n1 I1_I2066_G27_12n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I198_XG_MN0 (I1_I2066_G27_0 I1_I2066_P27_12n XI1_I2066_I198_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I198_XG_MN1 (XI1_I2066_I198_XG_n1 I1_I2066_G11_0n I1_I2066_G27_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I194_XG_MN2 (XI1_I2066_I194_XG_n1 I1_I2066_G23_8n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I194_XG_MN0 (I1_I2066_G23_0 I1_I2066_P23_8n XI1_I2066_I194_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I194_XG_MN1 (XI1_I2066_I194_XG_n1 I1_I2066_G7_0n I1_I2066_G23_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I311_XG_MN2 (XI0_I1660_I311_XG_n1 I0_I1660_G58_55n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I311_XG_MN0 (I0_I1660_G58_51 I0_I1660_P58_55n XI0_I1660_I311_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I311_XG_MN1 (XI0_I1660_I311_XG_n1 I0_I1660_G54_51n I0_I1660_G58_51 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I307_XG_MN2 (XI0_I1660_I307_XG_n1 I0_I1660_G54_51n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I307_XG_MN0 (I0_I1660_G54_47 I0_I1660_P54_51n XI0_I1660_I307_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I307_XG_MN1 (XI0_I1660_I307_XG_n1 I0_I1660_G50_47n I0_I1660_G54_47 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I313_XG_MN2 (XI0_I1660_I313_XG_n1 I0_I1660_G60_57n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I313_XG_MN0 (I0_I1660_G60_53 I0_I1660_P60_57n XI0_I1660_I313_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I313_XG_MN1 (XI0_I1660_I313_XG_n1 I0_I1660_G56_53n I0_I1660_G60_53 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I187_XG_MN2 (XI0_I1660_I187_XG_n1 I0_I1660_gn57 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I187_XG_MN0 (I0_I1660_G57_56 I0_I1660_pn57 XI0_I1660_I187_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I187_XG_MN1 (XI0_I1660_I187_XG_n1 I0_I1660_gn56 I0_I1660_G57_56 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I181_XG_MN2 (XI0_I1660_I181_XG_n1 I0_I1660_gn51 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I181_XG_MN0 (I0_I1660_G51_50 I0_I1660_pn51 XI0_I1660_I181_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I181_XG_MN1 (XI0_I1660_I181_XG_n1 I0_I1660_gn50 I0_I1660_G51_50 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I97_XG_MN2 (XI1_I1850_I97_XG_n1 I1_I1850_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I97_XG_MN0 (I1_I1850_G31_30 I1_I1850_pn31 XI1_I1850_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I97_XG_MN1 (XI1_I1850_I97_XG_n1 I1_I1850_gn30 I1_I1850_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I92_XG_MN2 (XI1_I1850_I92_XG_n1 I1_I1850_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I92_XG_MN0 (I1_I1850_G26_25 I1_I1850_pn26 XI1_I1850_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I92_XG_MN1 (XI1_I1850_I92_XG_n1 I1_I1850_gn25 I1_I1850_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I153_XG_MN2 (XI1_I1850_I153_XG_n1 I1_I1850_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I153_XG_MN0 (I1_I1850_G28_21 I1_I1850_P28_25n XI1_I1850_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I153_XG_MN1 (XI1_I1850_I153_XG_n1 I1_I1850_G24_21n I1_I1850_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I151_XG_MN2 (XI1_I1850_I151_XG_n1 I1_I1850_G26_23n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I151_XG_MN0 (I1_I1850_G26_19 I1_I1850_P26_23n XI1_I1850_I151_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I151_XG_MN1 (XI1_I1850_I151_XG_n1 I1_I1850_G22_19n I1_I1850_G26_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I199_XG_MN2 (XI1_I1850_I199_XG_n1 I1_I1850_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I199_XG_MN0 (I1_I1850_G28_0 I1_I1850_P28_13n XI1_I1850_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I199_XG_MN1 (XI1_I1850_I199_XG_n1 I1_I1850_G12_0n I1_I1850_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I91_XG_MN2 (XI1_I1896_I91_XG_n1 I1_I1896_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I91_XG_MN0 (I1_I1896_G25_24 I1_I1896_pn25 XI1_I1896_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I91_XG_MN1 (XI1_I1896_I91_XG_n1 I1_I1896_gn24 I1_I1896_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I90_XG_MN2 (XI1_I1896_I90_XG_n1 I1_I1896_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I90_XG_MN0 (I1_I1896_G24_23 I1_I1896_pn24 XI1_I1896_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I90_XG_MN1 (XI1_I1896_I90_XG_n1 I1_I1896_gn23 I1_I1896_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I154_XG_MN2 (XI1_I1896_I154_XG_n1 I1_I1896_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I154_XG_MN0 (I1_I1896_G29_22 I1_I1896_P29_26n XI1_I1896_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I154_XG_MN1 (XI1_I1896_I154_XG_n1 I1_I1896_G25_22n I1_I1896_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I200_XG_MN2 (XI1_I1896_I200_XG_n1 I1_I1896_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I200_XG_MN0 (I1_I1896_G29_0 I1_I1896_P29_14n XI1_I1896_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I200_XG_MN1 (XI1_I1896_I200_XG_n1 I1_I1896_G13_0n I1_I1896_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I202_XG_MN2 (XI1_I1896_I202_XG_n1 I1_I1896_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I202_XG_MN0 (I1_c29_o I1_I1896_P31_16n XI1_I1896_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I202_XG_MN1 (XI1_I1896_I202_XG_n1 I1_I1896_G15_0n I1_c29_o VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I153_XG_MN2 (XI1_I1896_I153_XG_n1 I1_I1896_G28_25n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I153_XG_MN0 (I1_I1896_G28_21 I1_I1896_P28_25n XI1_I1896_I153_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I153_XG_MN1 (XI1_I1896_I153_XG_n1 I1_I1896_G24_21n I1_I1896_G28_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I199_XG_MN2 (XI1_I1896_I199_XG_n1 I1_I1896_G28_13n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I199_XG_MN0 (I1_I1896_G28_0 I1_I1896_P28_13n XI1_I1896_I199_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I199_XG_MN1 (XI1_I1896_I199_XG_n1 I1_I1896_G12_0n I1_I1896_G28_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I92_XG_MN2 (XI1_I1942_I92_XG_n1 I1_I1942_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I92_XG_MN0 (I1_I1942_G26_25 I1_I1942_pn26 XI1_I1942_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I92_XG_MN1 (XI1_I1942_I92_XG_n1 I1_I1942_gn25 I1_I1942_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I156_XG_MN2 (XI1_I1942_I156_XG_n1 I1_I1942_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I156_XG_MN0 (I1_I1942_G31_24 I1_I1942_P31_28n XI1_I1942_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I156_XG_MN1 (XI1_I1942_I156_XG_n1 I1_I1942_G27_24n I1_I1942_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I92_XG_MN2 (XI1_I1988_I92_XG_n1 I1_I1988_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I92_XG_MN0 (I1_I1988_G26_25 I1_I1988_pn26 XI1_I1988_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I92_XG_MN1 (XI1_I1988_I92_XG_n1 I1_I1988_gn25 I1_I1988_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I93_XG_MN2 (XI1_I1988_I93_XG_n1 I1_I1988_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I93_XG_MN0 (I1_I1988_G27_26 I1_I1988_pn27 XI1_I1988_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I93_XG_MN1 (XI1_I1988_I93_XG_n1 I1_I1988_gn26 I1_I1988_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I156_XG_MN2 (XI1_I1988_I156_XG_n1 I1_I1988_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I156_XG_MN0 (I1_I1988_G31_24 I1_I1988_P31_28n XI1_I1988_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I156_XG_MN1 (XI1_I1988_I156_XG_n1 I1_I1988_G27_24n I1_I1988_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I91_XG_MN2 (XI1_I2066_I91_XG_n1 I1_I2066_gn25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I91_XG_MN0 (I1_I2066_G25_24 I1_I2066_pn25 XI1_I2066_I91_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I91_XG_MN1 (XI1_I2066_I91_XG_n1 I1_I2066_gn24 I1_I2066_G25_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I90_XG_MN2 (XI1_I2066_I90_XG_n1 I1_I2066_gn24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I90_XG_MN0 (I1_I2066_G24_23 I1_I2066_pn24 XI1_I2066_I90_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I90_XG_MN1 (XI1_I2066_I90_XG_n1 I1_I2066_gn23 I1_I2066_G24_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I154_XG_MN2 (XI1_I2066_I154_XG_n1 I1_I2066_G29_26n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I154_XG_MN0 (I1_I2066_G29_22 I1_I2066_P29_26n XI1_I2066_I154_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I154_XG_MN1 (XI1_I2066_I154_XG_n1 I1_I2066_G25_22n I1_I2066_G29_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I202_XG_MN2 (XI1_I2066_I202_XG_n1 I1_I2066_G31_16n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I202_XG_MN0 (I1_rco I1_I2066_P31_16n XI1_I2066_I202_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I202_XG_MN1 (XI1_I2066_I202_XG_n1 I1_I2066_G15_0n I1_rco VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I425_XG_MN2 (XI0_I1660_I425_XG_n1 I0_I1660_G62_47n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I425_XG_MN0 (I0_I1660_G62_31 I0_I1660_P62_47n XI0_I1660_I425_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I425_XG_MN1 (XI0_I1660_I425_XG_n1 I0_I1660_G46_31n I0_I1660_G62_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I315_XG_MN2 (XI0_I1660_I315_XG_n1 I0_I1660_G62_59n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I315_XG_MN0 (I0_I1660_G62_55 I0_I1660_P62_59n XI0_I1660_I315_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I315_XG_MN1 (XI0_I1660_I315_XG_n1 I0_I1660_G58_55n I0_I1660_G62_55 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I188_XG_MN2 (XI0_I1660_I188_XG_n1 I0_I1660_gn58 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I188_XG_MN0 (I0_I1660_G58_57 I0_I1660_pn58 XI0_I1660_I188_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I188_XG_MN1 (XI0_I1660_I188_XG_n1 I0_I1660_gn57 I0_I1660_G58_57 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I189_XG_MN2 (XI0_I1660_I189_XG_n1 I0_I1660_gn59 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I189_XG_MN0 (I0_I1660_G59_58 I0_I1660_pn59 XI0_I1660_I189_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I189_XG_MN1 (XI0_I1660_I189_XG_n1 I0_I1660_gn58 I0_I1660_G59_58 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I184_XG_MN2 (XI0_I1660_I184_XG_n1 I0_I1660_gn54 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I184_XG_MN0 (I0_I1660_G54_53 I0_I1660_pn54 XI0_I1660_I184_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I184_XG_MN1 (XI0_I1660_I184_XG_n1 I0_I1660_gn53 I0_I1660_G54_53 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I186_XG_MN2 (XI0_I1660_I186_XG_n1 I0_I1660_gn56 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I186_XG_MN0 (I0_I1660_G56_55 I0_I1660_pn56 XI0_I1660_I186_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I186_XG_MN1 (XI0_I1660_I186_XG_n1 I0_I1660_gn55 I0_I1660_G56_55 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I185_XG_MN2 (XI0_I1660_I185_XG_n1 I0_I1660_gn55 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I185_XG_MN0 (I0_I1660_G55_54 I0_I1660_pn55 XI0_I1660_I185_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I185_XG_MN1 (XI0_I1660_I185_XG_n1 I0_I1660_gn54 I0_I1660_G55_54 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I182_XG_MN2 (XI0_I1660_I182_XG_n1 I0_I1660_gn52 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I182_XG_MN0 (I0_I1660_G52_51 I0_I1660_pn52 XI0_I1660_I182_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I182_XG_MN1 (XI0_I1660_I182_XG_n1 I0_I1660_gn51 I0_I1660_G52_51 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I96_XG_MN2 (XI1_I1850_I96_XG_n1 I1_I1850_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I96_XG_MN0 (I1_I1850_G30_29 I1_I1850_pn30 XI1_I1850_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I96_XG_MN1 (XI1_I1850_I96_XG_n1 I1_I1850_gn29 I1_I1850_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I93_XG_MN2 (XI1_I1850_I93_XG_n1 I1_I1850_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I93_XG_MN0 (I1_I1850_G27_26 I1_I1850_pn27 XI1_I1850_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I93_XG_MN1 (XI1_I1850_I93_XG_n1 I1_I1850_gn26 I1_I1850_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I155_XG_MN2 (XI1_I1850_I155_XG_n1 I1_I1850_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I155_XG_MN0 (I1_I1850_G30_23 I1_I1850_P30_27n XI1_I1850_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I155_XG_MN1 (XI1_I1850_I155_XG_n1 I1_I1850_G26_23n I1_I1850_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I201_XG_MN2 (XI1_I1850_I201_XG_n1 I1_I1850_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I201_XG_MN0 (I1_c28_m I1_I1850_P30_15n XI1_I1850_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I201_XG_MN1 (XI1_I1850_I201_XG_n1 I1_I1850_G14_0n I1_c28_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I92_XG_MN2 (XI1_I1896_I92_XG_n1 I1_I1896_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I92_XG_MN0 (I1_I1896_G26_25 I1_I1896_pn26 XI1_I1896_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I92_XG_MN1 (XI1_I1896_I92_XG_n1 I1_I1896_gn25 I1_I1896_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I93_XG_MN2 (XI1_I1896_I93_XG_n1 I1_I1896_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I93_XG_MN0 (I1_I1896_G27_26 I1_I1896_pn27 XI1_I1896_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I93_XG_MN1 (XI1_I1896_I93_XG_n1 I1_I1896_gn26 I1_I1896_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I156_XG_MN2 (XI1_I1896_I156_XG_n1 I1_I1896_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I156_XG_MN0 (I1_I1896_G31_24 I1_I1896_P31_28n XI1_I1896_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I156_XG_MN1 (XI1_I1896_I156_XG_n1 I1_I1896_G27_24n I1_I1896_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I155_XG_MN2 (XI1_I1896_I155_XG_n1 I1_I1896_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I155_XG_MN0 (I1_I1896_G30_23 I1_I1896_P30_27n XI1_I1896_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I155_XG_MN1 (XI1_I1896_I155_XG_n1 I1_I1896_G26_23n I1_I1896_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I201_XG_MN2 (XI1_I1896_I201_XG_n1 I1_I1896_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I201_XG_MN0 (I1_c29_m I1_I1896_P30_15n XI1_I1896_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I201_XG_MN1 (XI1_I1896_I201_XG_n1 I1_I1896_G14_0n I1_c29_m VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I93_XG_MN2 (XI1_I1942_I93_XG_n1 I1_I1942_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I93_XG_MN0 (I1_I1942_G27_26 I1_I1942_pn27 XI1_I1942_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I93_XG_MN1 (XI1_I1942_I93_XG_n1 I1_I1942_gn26 I1_I1942_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I94_XG_MN2 (XI1_I1942_I94_XG_n1 I1_I1942_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I94_XG_MN0 (I1_I1942_G28_27 I1_I1942_pn28 XI1_I1942_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I94_XG_MN1 (XI1_I1942_I94_XG_n1 I1_I1942_gn27 I1_I1942_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I95_XG_MN2 (XI1_I1988_I95_XG_n1 I1_I1988_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I95_XG_MN0 (I1_I1988_G29_28 I1_I1988_pn29 XI1_I1988_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I95_XG_MN1 (XI1_I1988_I95_XG_n1 I1_I1988_gn28 I1_I1988_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1988_I94_XG_MN2 (XI1_I1988_I94_XG_n1 I1_I1988_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1988_I94_XG_MN0 (I1_I1988_G28_27 I1_I1988_pn28 XI1_I1988_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1988_I94_XG_MN1 (XI1_I1988_I94_XG_n1 I1_I1988_gn27 I1_I1988_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I92_XG_MN2 (XI1_I2066_I92_XG_n1 I1_I2066_gn26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I92_XG_MN0 (I1_I2066_G26_25 I1_I2066_pn26 XI1_I2066_I92_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I92_XG_MN1 (XI1_I2066_I92_XG_n1 I1_I2066_gn25 I1_I2066_G26_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I93_XG_MN2 (XI1_I2066_I93_XG_n1 I1_I2066_gn27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I93_XG_MN0 (I1_I2066_G27_26 I1_I2066_pn27 XI1_I2066_I93_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I93_XG_MN1 (XI1_I2066_I93_XG_n1 I1_I2066_gn26 I1_I2066_G27_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I155_XG_MN2 (XI1_I2066_I155_XG_n1 I1_I2066_G30_27n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I155_XG_MN0 (I1_I2066_G30_23 I1_I2066_P30_27n XI1_I2066_I155_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I155_XG_MN1 (XI1_I2066_I155_XG_n1 I1_I2066_G26_23n I1_I2066_G30_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I201_XG_MN2 (XI1_I2066_I201_XG_n1 I1_I2066_G30_15n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I201_XG_MN0 (I1_rcm I1_I2066_P30_15n XI1_I2066_I201_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I201_XG_MN1 (XI1_I2066_I201_XG_n1 I1_I2066_G14_0n I1_rcm VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I156_XG_MN2 (XI1_I2066_I156_XG_n1 I1_I2066_G31_28n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I156_XG_MN0 (I1_I2066_G31_24 I1_I2066_P31_28n XI1_I2066_I156_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I156_XG_MN1 (XI1_I2066_I156_XG_n1 I1_I2066_G27_24n I1_I2066_G31_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I200_XG_MN2 (XI1_I2066_I200_XG_n1 I1_I2066_G29_14n VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I200_XG_MN0 (I1_I2066_G29_0 I1_I2066_P29_14n XI1_I2066_I200_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I200_XG_MN1 (XI1_I2066_I200_XG_n1 I1_I2066_G13_0n I1_I2066_G29_0 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I190_XG_MN2 (XI0_I1660_I190_XG_n1 I0_I1660_gn60 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I190_XG_MN0 (I0_I1660_G60_59 I0_I1660_pn60 XI0_I1660_I190_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I190_XG_MN1 (XI0_I1660_I190_XG_n1 I0_I1660_gn59 I0_I1660_G60_59 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I183_XG_MN2 (XI0_I1660_I183_XG_n1 I0_I1660_gn53 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I183_XG_MN0 (I0_I1660_G53_52 I0_I1660_pn53 XI0_I1660_I183_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I183_XG_MN1 (XI0_I1660_I183_XG_n1 I0_I1660_gn52 I0_I1660_G53_52 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I95_XG_MN2 (XI1_I1850_I95_XG_n1 I1_I1850_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I95_XG_MN0 (I1_I1850_G29_28 I1_I1850_pn29 XI1_I1850_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I95_XG_MN1 (XI1_I1850_I95_XG_n1 I1_I1850_gn28 I1_I1850_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1850_I94_XG_MN2 (XI1_I1850_I94_XG_n1 I1_I1850_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1850_I94_XG_MN0 (I1_I1850_G28_27 I1_I1850_pn28 XI1_I1850_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1850_I94_XG_MN1 (XI1_I1850_I94_XG_n1 I1_I1850_gn27 I1_I1850_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I94_XG_MN2 (XI1_I1896_I94_XG_n1 I1_I1896_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I94_XG_MN0 (I1_I1896_G28_27 I1_I1896_pn28 XI1_I1896_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I94_XG_MN1 (XI1_I1896_I94_XG_n1 I1_I1896_gn27 I1_I1896_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I95_XG_MN2 (XI1_I1896_I95_XG_n1 I1_I1896_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I95_XG_MN0 (I1_I1896_G29_28 I1_I1896_pn29 XI1_I1896_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I95_XG_MN1 (XI1_I1896_I95_XG_n1 I1_I1896_gn28 I1_I1896_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I97_XG_MN2 (XI1_I1896_I97_XG_n1 I1_I1896_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I97_XG_MN0 (I1_I1896_G31_30 I1_I1896_pn31 XI1_I1896_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I97_XG_MN1 (XI1_I1896_I97_XG_n1 I1_I1896_gn30 I1_I1896_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1896_I96_XG_MN2 (XI1_I1896_I96_XG_n1 I1_I1896_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1896_I96_XG_MN0 (I1_I1896_G30_29 I1_I1896_pn30 XI1_I1896_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1896_I96_XG_MN1 (XI1_I1896_I96_XG_n1 I1_I1896_gn29 I1_I1896_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I95_XG_MN2 (XI1_I1942_I95_XG_n1 I1_I1942_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I95_XG_MN0 (I1_I1942_G29_28 I1_I1942_pn29 XI1_I1942_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I95_XG_MN1 (XI1_I1942_I95_XG_n1 I1_I1942_gn28 I1_I1942_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I97_XG_MN2 (XI1_I1942_I97_XG_n1 I1_I1942_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I97_XG_MN0 (I1_I1942_G31_30 I1_I1942_pn31 XI1_I1942_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I97_XG_MN1 (XI1_I1942_I97_XG_n1 I1_I1942_gn30 I1_I1942_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I1942_I96_XG_MN2 (XI1_I1942_I96_XG_n1 I1_I1942_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I1942_I96_XG_MN0 (I1_I1942_G30_29 I1_I1942_pn30 XI1_I1942_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I1942_I96_XG_MN1 (XI1_I1942_I96_XG_n1 I1_I1942_gn29 I1_I1942_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I97_XG_MN2 (XI1_I2066_I97_XG_n1 I1_I2066_gn31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I97_XG_MN0 (I1_I2066_G31_30 I1_I2066_pn31 XI1_I2066_I97_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I97_XG_MN1 (XI1_I2066_I97_XG_n1 I1_I2066_gn30 I1_I2066_G31_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I96_XG_MN2 (XI1_I2066_I96_XG_n1 I1_I2066_gn30 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I96_XG_MN0 (I1_I2066_G30_29 I1_I2066_pn30 XI1_I2066_I96_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I96_XG_MN1 (XI1_I2066_I96_XG_n1 I1_I2066_gn29 I1_I2066_G30_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I95_XG_MN2 (XI1_I2066_I95_XG_n1 I1_I2066_gn29 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I95_XG_MN0 (I1_I2066_G29_28 I1_I2066_pn29 XI1_I2066_I95_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I95_XG_MN1 (XI1_I2066_I95_XG_n1 I1_I2066_gn28 I1_I2066_G29_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI1_I2066_I94_XG_MN2 (XI1_I2066_I94_XG_n1 I1_I2066_gn28 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI1_I2066_I94_XG_MN0 (I1_I2066_G28_27 I1_I2066_pn28 XI1_I2066_I94_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI1_I2066_I94_XG_MN1 (XI1_I2066_I94_XG_n1 I1_I2066_gn27 I1_I2066_G28_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I192_XG_MN2 (XI0_I1660_I192_XG_n1 I0_I1660_gn62 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I192_XG_MN0 (I0_I1660_G62_61 I0_I1660_pn62 XI0_I1660_I192_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I192_XG_MN1 (XI0_I1660_I192_XG_n1 I0_I1660_gn61 I0_I1660_G62_61 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I193_XG_MN2 (XI0_I1660_I193_XG_n1 I0_I1660_gn63 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I193_XG_MN0 (I0_I1660_G63_62 I0_I1660_pn63 XI0_I1660_I193_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I193_XG_MN1 (XI0_I1660_I193_XG_n1 I0_I1660_gn62 I0_I1660_G63_62 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I1660_I191_XG_MN2 (XI0_I1660_I191_XG_n1 I0_I1660_gn61 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I1660_I191_XG_MN0 (I0_I1660_G61_60 I0_I1660_pn61 XI0_I1660_I191_XG_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I1660_I191_XG_MN1 (XI0_I1660_I191_XG_n1 I0_I1660_gn60 I0_I1660_G61_60 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I530_MN11 (VSS I0_B_1_b3_4 XI0_I530_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I530_MN14 (VSS XI0_I530_xbn XI0_I530_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I530_MN16 (XI0_I530_xn2 I0_B_1_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I530_MN15 (I0_pp0_27 XI0_I530_xan XI0_I530_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I530_MN13 (XI0_I530_xn1 XI0_I530_xn I0_pp0_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I530_MN2 (VSS I0_A_27_b3_0 XI0_I530_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I530_MN4 (XI0_I530_n2 I0_A_26_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I530_MN3 (XI0_I530_xn I0_two0_b3_4 XI0_I530_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I530_MN1 (XI0_I530_n1 I0_one0_b3_4 XI0_I530_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I530_MN9 (VSS XI0_I530_xn XI0_I530_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I531_MN11 (VSS I0_B_1_b3_4 XI0_I531_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I531_MN14 (VSS XI0_I531_xbn XI0_I531_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I531_MN16 (XI0_I531_xn2 I0_B_1_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I531_MN15 (I0_pp0_28 XI0_I531_xan XI0_I531_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I531_MN13 (XI0_I531_xn1 XI0_I531_xn I0_pp0_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I531_MN2 (VSS I0_A_28_b3_0 XI0_I531_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I531_MN4 (XI0_I531_n2 I0_A_27_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I531_MN3 (XI0_I531_xn I0_two0_b3_5 XI0_I531_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I531_MN1 (XI0_I531_n1 I0_one0_b3_5 XI0_I531_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I531_MN9 (VSS XI0_I531_xn XI0_I531_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I532_MN11 (VSS I0_B_1_b3_5 XI0_I532_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I532_MN14 (VSS XI0_I532_xbn XI0_I532_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I532_MN16 (XI0_I532_xn2 I0_B_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I532_MN15 (I0_pp0_29 XI0_I532_xan XI0_I532_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I532_MN13 (XI0_I532_xn1 XI0_I532_xn I0_pp0_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I532_MN2 (VSS I0_A_29_b3_0 XI0_I532_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I532_MN4 (XI0_I532_n2 I0_A_28_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I532_MN3 (XI0_I532_xn I0_two0_b3_5 XI0_I532_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I532_MN1 (XI0_I532_n1 I0_one0_b3_5 XI0_I532_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I532_MN9 (VSS XI0_I532_xn XI0_I532_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I534_MN11 (VSS I0_B_1_b3_5 XI0_I534_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I534_MN14 (VSS XI0_I534_xbn XI0_I534_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I534_MN16 (XI0_I534_xn2 I0_B_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I534_MN15 (I0_pp0_31 XI0_I534_xan XI0_I534_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I534_MN13 (XI0_I534_xn1 XI0_I534_xn I0_pp0_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I534_MN2 (VSS I0_A_31_b3_0 XI0_I534_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I534_MN4 (XI0_I534_n2 I0_A_30_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I534_MN3 (XI0_I534_xn I0_two0_b3_5 XI0_I534_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I534_MN1 (XI0_I534_n1 I0_one0_b3_5 XI0_I534_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I534_MN9 (VSS XI0_I534_xn XI0_I534_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I588_MN11 (VSS I0_B_3_b3_5 XI0_I588_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I588_MN14 (VSS XI0_I588_xbn XI0_I588_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I588_MN16 (XI0_I588_xn2 I0_B_3_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I588_MN15 (I0_pp1_30 XI0_I588_xan XI0_I588_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I588_MN13 (XI0_I588_xn1 XI0_I588_xn I0_pp1_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I588_MN2 (VSS I0_A_30_b3_0 XI0_I588_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I588_MN4 (XI0_I588_n2 I0_A_29_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I588_MN3 (XI0_I588_xn I0_two1_b3_5 XI0_I588_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I588_MN1 (XI0_I588_n1 I0_one1_b3_5 XI0_I588_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I588_MN9 (VSS XI0_I588_xn XI0_I588_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I590_MN11 (VSS I0_B_3_b3_5 XI0_I590_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I590_MN14 (VSS XI0_I590_xbn XI0_I590_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I590_MN16 (XI0_I590_xn2 I0_B_3_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I590_MN15 (I0_pp1_32 XI0_I590_xan XI0_I590_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I590_MN13 (XI0_I590_xn1 XI0_I590_xn I0_pp1_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I590_MN2 (VSS I0_A_31_b3_0 XI0_I590_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I590_MN4 (XI0_I590_n2 I0_A_31_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I590_MN3 (XI0_I590_xn I0_two1_b3_5 XI0_I590_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I590_MN1 (XI0_I590_n1 I0_one1_b3_5 XI0_I590_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I590_MN9 (VSS XI0_I590_xn XI0_I590_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I589_MN11 (VSS I0_B_3_b3_5 XI0_I589_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I589_MN14 (VSS XI0_I589_xbn XI0_I589_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I589_MN16 (XI0_I589_xn2 I0_B_3_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I589_MN15 (I0_pp1_31 XI0_I589_xan XI0_I589_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I589_MN13 (XI0_I589_xn1 XI0_I589_xn I0_pp1_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I589_MN2 (VSS I0_A_31_b3_0 XI0_I589_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I589_MN4 (XI0_I589_n2 I0_A_30_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I589_MN3 (XI0_I589_xn I0_two1_b3_5 XI0_I589_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I589_MN1 (XI0_I589_n1 I0_one1_b3_5 XI0_I589_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I589_MN9 (VSS XI0_I589_xn XI0_I589_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I643_MN11 (VSS I0_B_5_b3_5 XI0_I643_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I643_MN14 (VSS XI0_I643_xbn XI0_I643_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I643_MN16 (XI0_I643_xn2 I0_B_5_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I643_MN15 (I0_pp2_30 XI0_I643_xan XI0_I643_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I643_MN13 (XI0_I643_xn1 XI0_I643_xn I0_pp2_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I643_MN2 (VSS I0_A_30_b3_0 XI0_I643_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I643_MN4 (XI0_I643_n2 I0_A_29_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I643_MN3 (XI0_I643_xn I0_two2_b3_5 XI0_I643_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I643_MN1 (XI0_I643_n1 I0_one2_b3_5 XI0_I643_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I643_MN9 (VSS XI0_I643_xn XI0_I643_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I642_MN11 (VSS I0_B_5_b3_5 XI0_I642_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I642_MN14 (VSS XI0_I642_xbn XI0_I642_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I642_MN16 (XI0_I642_xn2 I0_B_5_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I642_MN15 (I0_pp2_29 XI0_I642_xan XI0_I642_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I642_MN13 (XI0_I642_xn1 XI0_I642_xn I0_pp2_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I642_MN2 (VSS I0_A_29_b3_0 XI0_I642_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I642_MN4 (XI0_I642_n2 I0_A_28_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I642_MN3 (XI0_I642_xn I0_two2_b3_5 XI0_I642_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I642_MN1 (XI0_I642_n1 I0_one2_b3_5 XI0_I642_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I642_MN9 (VSS XI0_I642_xn XI0_I642_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I644_MN11 (VSS I0_B_5_b3_5 XI0_I644_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I644_MN14 (VSS XI0_I644_xbn XI0_I644_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I644_MN16 (XI0_I644_xn2 I0_B_5_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I644_MN15 (I0_pp2_31 XI0_I644_xan XI0_I644_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I644_MN13 (XI0_I644_xn1 XI0_I644_xn I0_pp2_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I644_MN2 (VSS I0_A_31_b3_1 XI0_I644_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I644_MN4 (XI0_I644_n2 I0_A_30_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I644_MN3 (XI0_I644_xn I0_two2_b3_5 XI0_I644_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I644_MN1 (XI0_I644_n1 I0_one2_b3_5 XI0_I644_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I644_MN9 (VSS XI0_I644_xn XI0_I644_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I645_MN11 (VSS I0_B_5_b3_5 XI0_I645_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I645_MN14 (VSS XI0_I645_xbn XI0_I645_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I645_MN16 (XI0_I645_xn2 I0_B_5_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I645_MN15 (I0_pp2_32 XI0_I645_xan XI0_I645_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I645_MN13 (XI0_I645_xn1 XI0_I645_xn I0_pp2_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I645_MN2 (VSS I0_A_31_b3_1 XI0_I645_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I645_MN4 (XI0_I645_n2 I0_A_31_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I645_MN3 (XI0_I645_xn I0_two2_b3_5 XI0_I645_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I645_MN1 (XI0_I645_n1 I0_one2_b3_5 XI0_I645_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I645_MN9 (VSS XI0_I645_xn XI0_I645_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I521_MN11 (VSS I0_B_1_b3_3 XI0_I521_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I521_MN14 (VSS XI0_I521_xbn XI0_I521_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I521_MN16 (XI0_I521_xn2 I0_B_1_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I521_MN15 (I0_pp0_18 XI0_I521_xan XI0_I521_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I521_MN13 (XI0_I521_xn1 XI0_I521_xn I0_pp0_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I521_MN2 (VSS I0_A_18_b3_0 XI0_I521_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I521_MN4 (XI0_I521_n2 I0_A_17_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I521_MN3 (XI0_I521_xn I0_two0_b3_3 XI0_I521_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I521_MN1 (XI0_I521_n1 I0_one0_b3_3 XI0_I521_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I521_MN9 (VSS XI0_I521_xn XI0_I521_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I523_MN11 (VSS I0_B_1_b3_3 XI0_I523_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I523_MN14 (VSS XI0_I523_xbn XI0_I523_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I523_MN16 (XI0_I523_xn2 I0_B_1_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I523_MN15 (I0_pp0_20 XI0_I523_xan XI0_I523_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I523_MN13 (XI0_I523_xn1 XI0_I523_xn I0_pp0_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I523_MN2 (VSS I0_A_20_b3_0 XI0_I523_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I523_MN4 (XI0_I523_n2 I0_A_19_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I523_MN3 (XI0_I523_xn I0_two0_b3_3 XI0_I523_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I523_MN1 (XI0_I523_n1 I0_one0_b3_3 XI0_I523_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I523_MN9 (VSS XI0_I523_xn XI0_I523_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I524_MN11 (VSS I0_B_1_b3_3 XI0_I524_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I524_MN14 (VSS XI0_I524_xbn XI0_I524_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I524_MN16 (XI0_I524_xn2 I0_B_1_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I524_MN15 (I0_pp0_21 XI0_I524_xan XI0_I524_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I524_MN13 (XI0_I524_xn1 XI0_I524_xn I0_pp0_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I524_MN2 (VSS I0_A_21_b3_0 XI0_I524_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I524_MN4 (XI0_I524_n2 I0_A_20_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I524_MN3 (XI0_I524_xn I0_two0_b3_3 XI0_I524_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I524_MN1 (XI0_I524_n1 I0_one0_b3_3 XI0_I524_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I524_MN9 (VSS XI0_I524_xn XI0_I524_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I577_MN11 (VSS I0_B_3_b3_3 XI0_I577_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I577_MN14 (VSS XI0_I577_xbn XI0_I577_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I577_MN16 (XI0_I577_xn2 I0_B_3_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I577_MN15 (I0_pp1_19 XI0_I577_xan XI0_I577_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I577_MN13 (XI0_I577_xn1 XI0_I577_xn I0_pp1_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I577_MN2 (VSS I0_A_19_b3_0 XI0_I577_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I577_MN4 (XI0_I577_n2 I0_A_18_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I577_MN3 (XI0_I577_xn I0_two1_b3_3 XI0_I577_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I577_MN1 (XI0_I577_n1 I0_one1_b3_3 XI0_I577_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I577_MN9 (VSS XI0_I577_xn XI0_I577_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I525_MN11 (VSS I0_B_1_b3_3 XI0_I525_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I525_MN14 (VSS XI0_I525_xbn XI0_I525_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I525_MN16 (XI0_I525_xn2 I0_B_1_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I525_MN15 (I0_pp0_22 XI0_I525_xan XI0_I525_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I525_MN13 (XI0_I525_xn1 XI0_I525_xn I0_pp0_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I525_MN2 (VSS I0_A_22_b3_0 XI0_I525_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I525_MN4 (XI0_I525_n2 I0_A_21_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I525_MN3 (XI0_I525_xn I0_two0_b3_4 XI0_I525_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I525_MN1 (XI0_I525_n1 I0_one0_b3_4 XI0_I525_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I525_MN9 (VSS XI0_I525_xn XI0_I525_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I526_MN11 (VSS I0_B_1_b3_4 XI0_I526_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I526_MN14 (VSS XI0_I526_xbn XI0_I526_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I526_MN16 (XI0_I526_xn2 I0_B_1_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I526_MN15 (I0_pp0_23 XI0_I526_xan XI0_I526_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I526_MN13 (XI0_I526_xn1 XI0_I526_xn I0_pp0_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I526_MN2 (VSS I0_A_23_b3_0 XI0_I526_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I526_MN4 (XI0_I526_n2 I0_A_22_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I526_MN3 (XI0_I526_xn I0_two0_b3_4 XI0_I526_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I526_MN1 (XI0_I526_n1 I0_one0_b3_4 XI0_I526_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I526_MN9 (VSS XI0_I526_xn XI0_I526_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I580_MN11 (VSS I0_B_3_b3_3 XI0_I580_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I580_MN14 (VSS XI0_I580_xbn XI0_I580_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I580_MN16 (XI0_I580_xn2 I0_B_3_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I580_MN15 (I0_pp1_22 XI0_I580_xan XI0_I580_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I580_MN13 (XI0_I580_xn1 XI0_I580_xn I0_pp1_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I580_MN2 (VSS I0_A_22_b3_0 XI0_I580_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I580_MN4 (XI0_I580_n2 I0_A_21_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I580_MN3 (XI0_I580_xn I0_two1_b3_4 XI0_I580_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I580_MN1 (XI0_I580_n1 I0_one1_b3_4 XI0_I580_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I580_MN9 (VSS XI0_I580_xn XI0_I580_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I527_MN11 (VSS I0_B_1_b3_4 XI0_I527_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I527_MN14 (VSS XI0_I527_xbn XI0_I527_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I527_MN16 (XI0_I527_xn2 I0_B_1_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I527_MN15 (I0_pp0_24 XI0_I527_xan XI0_I527_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I527_MN13 (XI0_I527_xn1 XI0_I527_xn I0_pp0_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I527_MN2 (VSS I0_A_24_b3_0 XI0_I527_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I527_MN4 (XI0_I527_n2 I0_A_23_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I527_MN3 (XI0_I527_xn I0_two0_b3_4 XI0_I527_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I527_MN1 (XI0_I527_n1 I0_one0_b3_4 XI0_I527_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I527_MN9 (VSS XI0_I527_xn XI0_I527_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I528_MN11 (VSS I0_B_1_b3_4 XI0_I528_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I528_MN14 (VSS XI0_I528_xbn XI0_I528_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I528_MN16 (XI0_I528_xn2 I0_B_1_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I528_MN15 (I0_pp0_25 XI0_I528_xan XI0_I528_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I528_MN13 (XI0_I528_xn1 XI0_I528_xn I0_pp0_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I528_MN2 (VSS I0_A_25_b3_0 XI0_I528_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I528_MN4 (XI0_I528_n2 I0_A_24_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I528_MN3 (XI0_I528_xn I0_two0_b3_4 XI0_I528_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I528_MN1 (XI0_I528_n1 I0_one0_b3_4 XI0_I528_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I528_MN9 (VSS XI0_I528_xn XI0_I528_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I529_MN11 (VSS I0_B_1_b3_4 XI0_I529_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I529_MN14 (VSS XI0_I529_xbn XI0_I529_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I529_MN16 (XI0_I529_xn2 I0_B_1_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I529_MN15 (I0_pp0_26 XI0_I529_xan XI0_I529_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I529_MN13 (XI0_I529_xn1 XI0_I529_xn I0_pp0_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I529_MN2 (VSS I0_A_26_b3_0 XI0_I529_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I529_MN4 (XI0_I529_n2 I0_A_25_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I529_MN3 (XI0_I529_xn I0_two0_b3_4 XI0_I529_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I529_MN1 (XI0_I529_n1 I0_one0_b3_4 XI0_I529_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I529_MN9 (VSS XI0_I529_xn XI0_I529_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I585_MN11 (VSS I0_B_3_b3_4 XI0_I585_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I585_MN14 (VSS XI0_I585_xbn XI0_I585_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I585_MN16 (XI0_I585_xn2 I0_B_3_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I585_MN15 (I0_pp1_27 XI0_I585_xan XI0_I585_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I585_MN13 (XI0_I585_xn1 XI0_I585_xn I0_pp1_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I585_MN2 (VSS I0_A_27_b3_0 XI0_I585_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I585_MN4 (XI0_I585_n2 I0_A_26_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I585_MN3 (XI0_I585_xn I0_two1_b3_4 XI0_I585_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I585_MN1 (XI0_I585_n1 I0_one1_b3_4 XI0_I585_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I585_MN9 (VSS XI0_I585_xn XI0_I585_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I586_MN11 (VSS I0_B_3_b3_4 XI0_I586_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I586_MN14 (VSS XI0_I586_xbn XI0_I586_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I586_MN16 (XI0_I586_xn2 I0_B_3_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I586_MN15 (I0_pp1_28 XI0_I586_xan XI0_I586_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I586_MN13 (XI0_I586_xn1 XI0_I586_xn I0_pp1_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I586_MN2 (VSS I0_A_28_b3_0 XI0_I586_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I586_MN4 (XI0_I586_n2 I0_A_27_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I586_MN3 (XI0_I586_xn I0_two1_b3_5 XI0_I586_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I586_MN1 (XI0_I586_n1 I0_one1_b3_5 XI0_I586_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I586_MN9 (VSS XI0_I586_xn XI0_I586_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I583_MN11 (VSS I0_B_3_b3_4 XI0_I583_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I583_MN14 (VSS XI0_I583_xbn XI0_I583_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I583_MN16 (XI0_I583_xn2 I0_B_3_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I583_MN15 (I0_pp1_25 XI0_I583_xan XI0_I583_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I583_MN13 (XI0_I583_xn1 XI0_I583_xn I0_pp1_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I583_MN2 (VSS I0_A_25_b3_0 XI0_I583_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I583_MN4 (XI0_I583_n2 I0_A_24_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I583_MN3 (XI0_I583_xn I0_two1_b3_4 XI0_I583_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I583_MN1 (XI0_I583_n1 I0_one1_b3_4 XI0_I583_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I583_MN9 (VSS XI0_I583_xn XI0_I583_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I533_MN11 (VSS I0_B_1_b3_5 XI0_I533_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I533_MN14 (VSS XI0_I533_xbn XI0_I533_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I533_MN16 (XI0_I533_xn2 I0_B_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I533_MN15 (I0_pp0_30 XI0_I533_xan XI0_I533_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I533_MN13 (XI0_I533_xn1 XI0_I533_xn I0_pp0_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I533_MN2 (VSS I0_A_30_b3_0 XI0_I533_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I533_MN4 (XI0_I533_n2 I0_A_29_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I533_MN3 (XI0_I533_xn I0_two0_b3_5 XI0_I533_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I533_MN1 (XI0_I533_n1 I0_one0_b3_5 XI0_I533_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I533_MN9 (VSS XI0_I533_xn XI0_I533_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I640_MN11 (VSS I0_B_5_b3_4 XI0_I640_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I640_MN14 (VSS XI0_I640_xbn XI0_I640_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I640_MN16 (XI0_I640_xn2 I0_B_5_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I640_MN15 (I0_pp2_27 XI0_I640_xan XI0_I640_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I640_MN13 (XI0_I640_xn1 XI0_I640_xn I0_pp2_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I640_MN2 (VSS I0_A_27_b3_0 XI0_I640_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I640_MN4 (XI0_I640_n2 I0_A_26_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I640_MN3 (XI0_I640_xn I0_two2_b3_4 XI0_I640_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I640_MN1 (XI0_I640_n1 I0_one2_b3_4 XI0_I640_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I640_MN9 (VSS XI0_I640_xn XI0_I640_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I535_MN11 (VSS I0_B_1_b3_5 XI0_I535_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I535_MN14 (VSS XI0_I535_xbn XI0_I535_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I535_MN16 (XI0_I535_xn2 I0_B_1_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I535_MN15 (I0_pp0_32 XI0_I535_xan XI0_I535_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I535_MN13 (XI0_I535_xn1 XI0_I535_xn I0_pp0_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I535_MN2 (VSS I0_A_31_b3_0 XI0_I535_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I535_MN4 (XI0_I535_n2 I0_A_31_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I535_MN3 (XI0_I535_xn I0_two0_b3_5 XI0_I535_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I535_MN1 (XI0_I535_n1 I0_one0_b3_5 XI0_I535_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I535_MN9 (VSS XI0_I535_xn XI0_I535_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I587_MN11 (VSS I0_B_3_b3_5 XI0_I587_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I587_MN14 (VSS XI0_I587_xbn XI0_I587_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I587_MN16 (XI0_I587_xn2 I0_B_3_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I587_MN15 (I0_pp1_29 XI0_I587_xan XI0_I587_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I587_MN13 (XI0_I587_xn1 XI0_I587_xn I0_pp1_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I587_MN2 (VSS I0_A_29_b3_0 XI0_I587_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I587_MN4 (XI0_I587_n2 I0_A_28_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I587_MN3 (XI0_I587_xn I0_two1_b3_5 XI0_I587_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I587_MN1 (XI0_I587_n1 I0_one1_b3_5 XI0_I587_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I587_MN9 (VSS XI0_I587_xn XI0_I587_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I641_MN11 (VSS I0_B_5_b3_4 XI0_I641_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I641_MN14 (VSS XI0_I641_xbn XI0_I641_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I641_MN16 (XI0_I641_xn2 I0_B_5_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I641_MN15 (I0_pp2_28 XI0_I641_xan XI0_I641_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I641_MN13 (XI0_I641_xn1 XI0_I641_xn I0_pp2_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I641_MN2 (VSS I0_A_28_b3_0 XI0_I641_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I641_MN4 (XI0_I641_n2 I0_A_27_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I641_MN3 (XI0_I641_xn I0_two2_b3_5 XI0_I641_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I641_MN1 (XI0_I641_n1 I0_one2_b3_5 XI0_I641_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I641_MN9 (VSS XI0_I641_xn XI0_I641_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I520_MN11 (VSS I0_B_1_b3_3 XI0_I520_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I520_MN14 (VSS XI0_I520_xbn XI0_I520_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I520_MN16 (XI0_I520_xn2 I0_B_1_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I520_MN15 (I0_pp0_17 XI0_I520_xan XI0_I520_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I520_MN13 (XI0_I520_xn1 XI0_I520_xn I0_pp0_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I520_MN2 (VSS I0_A_17_b3_0 XI0_I520_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I520_MN4 (XI0_I520_n2 I0_A_16_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I520_MN3 (XI0_I520_xn I0_two0_b3_3 XI0_I520_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I520_MN1 (XI0_I520_n1 I0_one0_b3_3 XI0_I520_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I520_MN9 (VSS XI0_I520_xn XI0_I520_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I522_MN11 (VSS I0_B_1_b3_3 XI0_I522_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I522_MN14 (VSS XI0_I522_xbn XI0_I522_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I522_MN16 (XI0_I522_xn2 I0_B_1_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I522_MN15 (I0_pp0_19 XI0_I522_xan XI0_I522_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I522_MN13 (XI0_I522_xn1 XI0_I522_xn I0_pp0_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I522_MN2 (VSS I0_A_19_b3_0 XI0_I522_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I522_MN4 (XI0_I522_n2 I0_A_18_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I522_MN3 (XI0_I522_xn I0_two0_b3_3 XI0_I522_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I522_MN1 (XI0_I522_n1 I0_one0_b3_3 XI0_I522_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I522_MN9 (VSS XI0_I522_xn XI0_I522_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I576_MN11 (VSS I0_B_3_b3_3 XI0_I576_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I576_MN14 (VSS XI0_I576_xbn XI0_I576_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I576_MN16 (XI0_I576_xn2 I0_B_3_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I576_MN15 (I0_pp1_18 XI0_I576_xan XI0_I576_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I576_MN13 (XI0_I576_xn1 XI0_I576_xn I0_pp1_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I576_MN2 (VSS I0_A_18_b3_0 XI0_I576_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I576_MN4 (XI0_I576_n2 I0_A_17_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I576_MN3 (XI0_I576_xn I0_two1_b3_3 XI0_I576_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I576_MN1 (XI0_I576_n1 I0_one1_b3_3 XI0_I576_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I576_MN9 (VSS XI0_I576_xn XI0_I576_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I575_MN11 (VSS I0_B_3_b3_3 XI0_I575_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I575_MN14 (VSS XI0_I575_xbn XI0_I575_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I575_MN16 (XI0_I575_xn2 I0_B_3_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I575_MN15 (I0_pp1_17 XI0_I575_xan XI0_I575_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I575_MN13 (XI0_I575_xn1 XI0_I575_xn I0_pp1_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I575_MN2 (VSS I0_A_17_b3_0 XI0_I575_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I575_MN4 (XI0_I575_n2 I0_A_16_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I575_MN3 (XI0_I575_xn I0_two1_b3_3 XI0_I575_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I575_MN1 (XI0_I575_n1 I0_one1_b3_3 XI0_I575_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I575_MN9 (VSS XI0_I575_xn XI0_I575_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I579_MN11 (VSS I0_B_3_b3_3 XI0_I579_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I579_MN14 (VSS XI0_I579_xbn XI0_I579_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I579_MN16 (XI0_I579_xn2 I0_B_3_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I579_MN15 (I0_pp1_21 XI0_I579_xan XI0_I579_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I579_MN13 (XI0_I579_xn1 XI0_I579_xn I0_pp1_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I579_MN2 (VSS I0_A_21_b3_0 XI0_I579_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I579_MN4 (XI0_I579_n2 I0_A_20_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I579_MN3 (XI0_I579_xn I0_two1_b3_3 XI0_I579_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I579_MN1 (XI0_I579_n1 I0_one1_b3_3 XI0_I579_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I579_MN9 (VSS XI0_I579_xn XI0_I579_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I578_MN11 (VSS I0_B_3_b3_3 XI0_I578_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I578_MN14 (VSS XI0_I578_xbn XI0_I578_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I578_MN16 (XI0_I578_xn2 I0_B_3_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I578_MN15 (I0_pp1_20 XI0_I578_xan XI0_I578_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I578_MN13 (XI0_I578_xn1 XI0_I578_xn I0_pp1_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I578_MN2 (VSS I0_A_20_b3_0 XI0_I578_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I578_MN4 (XI0_I578_n2 I0_A_19_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I578_MN3 (XI0_I578_xn I0_two1_b3_3 XI0_I578_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I578_MN1 (XI0_I578_n1 I0_one1_b3_3 XI0_I578_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I578_MN9 (VSS XI0_I578_xn XI0_I578_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I581_MN11 (VSS I0_B_3_b3_4 XI0_I581_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I581_MN14 (VSS XI0_I581_xbn XI0_I581_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I581_MN16 (XI0_I581_xn2 I0_B_3_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I581_MN15 (I0_pp1_23 XI0_I581_xan XI0_I581_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I581_MN13 (XI0_I581_xn1 XI0_I581_xn I0_pp1_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I581_MN2 (VSS I0_A_23_b3_0 XI0_I581_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I581_MN4 (XI0_I581_n2 I0_A_22_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I581_MN3 (XI0_I581_xn I0_two1_b3_4 XI0_I581_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I581_MN1 (XI0_I581_n1 I0_one1_b3_4 XI0_I581_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I581_MN9 (VSS XI0_I581_xn XI0_I581_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I634_MN11 (VSS I0_B_5_b3_3 XI0_I634_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I634_MN14 (VSS XI0_I634_xbn XI0_I634_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I634_MN16 (XI0_I634_xn2 I0_B_5_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I634_MN15 (I0_pp2_21 XI0_I634_xan XI0_I634_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I634_MN13 (XI0_I634_xn1 XI0_I634_xn I0_pp2_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I634_MN2 (VSS I0_A_21_b3_0 XI0_I634_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I634_MN4 (XI0_I634_n2 I0_A_20_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I634_MN3 (XI0_I634_xn I0_two2_b3_3 XI0_I634_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I634_MN1 (XI0_I634_n1 I0_one2_b3_3 XI0_I634_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I634_MN9 (VSS XI0_I634_xn XI0_I634_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I582_MN11 (VSS I0_B_3_b3_4 XI0_I582_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I582_MN14 (VSS XI0_I582_xbn XI0_I582_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I582_MN16 (XI0_I582_xn2 I0_B_3_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I582_MN15 (I0_pp1_24 XI0_I582_xan XI0_I582_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I582_MN13 (XI0_I582_xn1 XI0_I582_xn I0_pp1_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I582_MN2 (VSS I0_A_24_b3_0 XI0_I582_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I582_MN4 (XI0_I582_n2 I0_A_23_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I582_MN3 (XI0_I582_xn I0_two1_b3_4 XI0_I582_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I582_MN1 (XI0_I582_n1 I0_one1_b3_4 XI0_I582_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I582_MN9 (VSS XI0_I582_xn XI0_I582_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I638_MN11 (VSS I0_B_5_b3_4 XI0_I638_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I638_MN14 (VSS XI0_I638_xbn XI0_I638_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I638_MN16 (XI0_I638_xn2 I0_B_5_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I638_MN15 (I0_pp2_25 XI0_I638_xan XI0_I638_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I638_MN13 (XI0_I638_xn1 XI0_I638_xn I0_pp2_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I638_MN2 (VSS I0_A_25_b3_0 XI0_I638_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I638_MN4 (XI0_I638_n2 I0_A_24_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I638_MN3 (XI0_I638_xn I0_two2_b3_4 XI0_I638_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I638_MN1 (XI0_I638_n1 I0_one2_b3_4 XI0_I638_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I638_MN9 (VSS XI0_I638_xn XI0_I638_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I636_MN11 (VSS I0_B_5_b3_4 XI0_I636_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I636_MN14 (VSS XI0_I636_xbn XI0_I636_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I636_MN16 (XI0_I636_xn2 I0_B_5_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I636_MN15 (I0_pp2_23 XI0_I636_xan XI0_I636_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I636_MN13 (XI0_I636_xn1 XI0_I636_xn I0_pp2_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I636_MN2 (VSS I0_A_23_b3_0 XI0_I636_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I636_MN4 (XI0_I636_n2 I0_A_22_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I636_MN3 (XI0_I636_xn I0_two2_b3_4 XI0_I636_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I636_MN1 (XI0_I636_n1 I0_one2_b3_4 XI0_I636_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I636_MN9 (VSS XI0_I636_xn XI0_I636_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I584_MN11 (VSS I0_B_3_b3_4 XI0_I584_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I584_MN14 (VSS XI0_I584_xbn XI0_I584_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I584_MN16 (XI0_I584_xn2 I0_B_3_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I584_MN15 (I0_pp1_26 XI0_I584_xan XI0_I584_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I584_MN13 (XI0_I584_xn1 XI0_I584_xn I0_pp1_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I584_MN2 (VSS I0_A_26_b3_0 XI0_I584_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I584_MN4 (XI0_I584_n2 I0_A_25_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I584_MN3 (XI0_I584_xn I0_two1_b3_4 XI0_I584_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I584_MN1 (XI0_I584_n1 I0_one1_b3_4 XI0_I584_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I584_MN9 (VSS XI0_I584_xn XI0_I584_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I639_MN11 (VSS I0_B_5_b3_4 XI0_I639_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I639_MN14 (VSS XI0_I639_xbn XI0_I639_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I639_MN16 (XI0_I639_xn2 I0_B_5_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I639_MN15 (I0_pp2_26 XI0_I639_xan XI0_I639_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I639_MN13 (XI0_I639_xn1 XI0_I639_xn I0_pp2_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I639_MN2 (VSS I0_A_26_b3_0 XI0_I639_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I639_MN4 (XI0_I639_n2 I0_A_25_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I639_MN3 (XI0_I639_xn I0_two2_b3_4 XI0_I639_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I639_MN1 (XI0_I639_n1 I0_one2_b3_4 XI0_I639_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I639_MN9 (VSS XI0_I639_xn XI0_I639_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I637_MN11 (VSS I0_B_5_b3_4 XI0_I637_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I637_MN14 (VSS XI0_I637_xbn XI0_I637_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I637_MN16 (XI0_I637_xn2 I0_B_5_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I637_MN15 (I0_pp2_24 XI0_I637_xan XI0_I637_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I637_MN13 (XI0_I637_xn1 XI0_I637_xn I0_pp2_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I637_MN2 (VSS I0_A_24_b3_0 XI0_I637_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I637_MN4 (XI0_I637_n2 I0_A_23_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I637_MN3 (XI0_I637_xn I0_two2_b3_4 XI0_I637_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I637_MN1 (XI0_I637_n1 I0_one2_b3_4 XI0_I637_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I637_MN9 (VSS XI0_I637_xn XI0_I637_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I696_MN11 (VSS I0_B_7_b3_4 XI0_I696_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I696_MN14 (VSS XI0_I696_xbn XI0_I696_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I696_MN16 (XI0_I696_xn2 I0_B_7_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I696_MN15 (I0_pp3_28 XI0_I696_xan XI0_I696_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I696_MN13 (XI0_I696_xn1 XI0_I696_xn I0_pp3_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I696_MN2 (VSS I0_A_28_b3_1 XI0_I696_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I696_MN4 (XI0_I696_n2 I0_A_27_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I696_MN3 (XI0_I696_xn I0_two3_b3_5 XI0_I696_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I696_MN1 (XI0_I696_n1 I0_one3_b3_5 XI0_I696_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I696_MN9 (VSS XI0_I696_xn XI0_I696_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I697_MN11 (VSS I0_B_7_b3_5 XI0_I697_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I697_MN14 (VSS XI0_I697_xbn XI0_I697_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I697_MN16 (XI0_I697_xn2 I0_B_7_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I697_MN15 (I0_pp3_29 XI0_I697_xan XI0_I697_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I697_MN13 (XI0_I697_xn1 XI0_I697_xn I0_pp3_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I697_MN2 (VSS I0_A_29_b3_1 XI0_I697_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I697_MN4 (XI0_I697_n2 I0_A_28_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I697_MN3 (XI0_I697_xn I0_two3_b3_5 XI0_I697_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I697_MN1 (XI0_I697_n1 I0_one3_b3_5 XI0_I697_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I697_MN9 (VSS XI0_I697_xn XI0_I697_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I700_MN11 (VSS I0_B_7_b3_5 XI0_I700_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I700_MN14 (VSS XI0_I700_xbn XI0_I700_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I700_MN16 (XI0_I700_xn2 I0_B_7_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I700_MN15 (I0_pp3_32 XI0_I700_xan XI0_I700_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I700_MN13 (XI0_I700_xn1 XI0_I700_xn I0_pp3_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I700_MN2 (VSS I0_A_31_b3_1 XI0_I700_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I700_MN4 (XI0_I700_n2 I0_A_31_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I700_MN3 (XI0_I700_xn I0_two3_b3_5 XI0_I700_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I700_MN1 (XI0_I700_n1 I0_one3_b3_5 XI0_I700_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I700_MN9 (VSS XI0_I700_xn XI0_I700_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I699_MN11 (VSS I0_B_7_b3_5 XI0_I699_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I699_MN14 (VSS XI0_I699_xbn XI0_I699_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I699_MN16 (XI0_I699_xn2 I0_B_7_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I699_MN15 (I0_pp3_31 XI0_I699_xan XI0_I699_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I699_MN13 (XI0_I699_xn1 XI0_I699_xn I0_pp3_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I699_MN2 (VSS I0_A_31_b3_1 XI0_I699_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I699_MN4 (XI0_I699_n2 I0_A_30_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I699_MN3 (XI0_I699_xn I0_two3_b3_5 XI0_I699_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I699_MN1 (XI0_I699_n1 I0_one3_b3_5 XI0_I699_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I699_MN9 (VSS XI0_I699_xn XI0_I699_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I698_MN11 (VSS I0_B_7_b3_5 XI0_I698_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I698_MN14 (VSS XI0_I698_xbn XI0_I698_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I698_MN16 (XI0_I698_xn2 I0_B_7_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I698_MN15 (I0_pp3_30 XI0_I698_xan XI0_I698_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I698_MN13 (XI0_I698_xn1 XI0_I698_xn I0_pp3_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I698_MN2 (VSS I0_A_30_b3_1 XI0_I698_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I698_MN4 (XI0_I698_n2 I0_A_29_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I698_MN3 (XI0_I698_xn I0_two3_b3_5 XI0_I698_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I698_MN1 (XI0_I698_n1 I0_one3_b3_5 XI0_I698_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I698_MN9 (VSS XI0_I698_xn XI0_I698_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I574_MN11 (VSS I0_B_3_b3_2 XI0_I574_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I574_MN14 (VSS XI0_I574_xbn XI0_I574_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I574_MN16 (XI0_I574_xn2 I0_B_3_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I574_MN15 (I0_pp1_16 XI0_I574_xan XI0_I574_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I574_MN13 (XI0_I574_xn1 XI0_I574_xn I0_pp1_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I574_MN2 (VSS I0_A_16_b3_0 XI0_I574_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I574_MN4 (XI0_I574_n2 I0_A_15_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I574_MN3 (XI0_I574_xn I0_two1_b3_2 XI0_I574_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I574_MN1 (XI0_I574_n1 I0_one1_b3_2 XI0_I574_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I574_MN9 (VSS XI0_I574_xn XI0_I574_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I629_MN11 (VSS I0_B_5_b3_2 XI0_I629_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I629_MN14 (VSS XI0_I629_xbn XI0_I629_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I629_MN16 (XI0_I629_xn2 I0_B_5_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I629_MN15 (I0_pp2_16 XI0_I629_xan XI0_I629_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I629_MN13 (XI0_I629_xn1 XI0_I629_xn I0_pp2_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I629_MN2 (VSS I0_A_16_b3_0 XI0_I629_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I629_MN4 (XI0_I629_n2 I0_A_15_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I629_MN3 (XI0_I629_xn I0_two2_b3_2 XI0_I629_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I629_MN1 (XI0_I629_n1 I0_one2_b3_2 XI0_I629_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I629_MN9 (VSS XI0_I629_xn XI0_I629_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I632_MN11 (VSS I0_B_5_b3_3 XI0_I632_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I632_MN14 (VSS XI0_I632_xbn XI0_I632_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I632_MN16 (XI0_I632_xn2 I0_B_5_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I632_MN15 (I0_pp2_19 XI0_I632_xan XI0_I632_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I632_MN13 (XI0_I632_xn1 XI0_I632_xn I0_pp2_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I632_MN2 (VSS I0_A_19_b3_0 XI0_I632_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I632_MN4 (XI0_I632_n2 I0_A_18_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I632_MN3 (XI0_I632_xn I0_two2_b3_3 XI0_I632_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I632_MN1 (XI0_I632_n1 I0_one2_b3_3 XI0_I632_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I632_MN9 (VSS XI0_I632_xn XI0_I632_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I631_MN11 (VSS I0_B_5_b3_3 XI0_I631_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I631_MN14 (VSS XI0_I631_xbn XI0_I631_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I631_MN16 (XI0_I631_xn2 I0_B_5_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I631_MN15 (I0_pp2_18 XI0_I631_xan XI0_I631_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I631_MN13 (XI0_I631_xn1 XI0_I631_xn I0_pp2_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I631_MN2 (VSS I0_A_18_b3_0 XI0_I631_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I631_MN4 (XI0_I631_n2 I0_A_17_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I631_MN3 (XI0_I631_xn I0_two2_b3_3 XI0_I631_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I631_MN1 (XI0_I631_n1 I0_one2_b3_3 XI0_I631_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I631_MN9 (VSS XI0_I631_xn XI0_I631_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I630_MN11 (VSS I0_B_5_b3_3 XI0_I630_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I630_MN14 (VSS XI0_I630_xbn XI0_I630_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I630_MN16 (XI0_I630_xn2 I0_B_5_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I630_MN15 (I0_pp2_17 XI0_I630_xan XI0_I630_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I630_MN13 (XI0_I630_xn1 XI0_I630_xn I0_pp2_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I630_MN2 (VSS I0_A_17_b3_0 XI0_I630_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I630_MN4 (XI0_I630_n2 I0_A_16_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I630_MN3 (XI0_I630_xn I0_two2_b3_3 XI0_I630_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I630_MN1 (XI0_I630_n1 I0_one2_b3_3 XI0_I630_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I630_MN9 (VSS XI0_I630_xn XI0_I630_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I633_MN11 (VSS I0_B_5_b3_3 XI0_I633_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I633_MN14 (VSS XI0_I633_xbn XI0_I633_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I633_MN16 (XI0_I633_xn2 I0_B_5_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I633_MN15 (I0_pp2_20 XI0_I633_xan XI0_I633_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I633_MN13 (XI0_I633_xn1 XI0_I633_xn I0_pp2_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I633_MN2 (VSS I0_A_20_b3_0 XI0_I633_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I633_MN4 (XI0_I633_n2 I0_A_19_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I633_MN3 (XI0_I633_xn I0_two2_b3_3 XI0_I633_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I633_MN1 (XI0_I633_n1 I0_one2_b3_3 XI0_I633_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I633_MN9 (VSS XI0_I633_xn XI0_I633_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I635_MN11 (VSS I0_B_5_b3_3 XI0_I635_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I635_MN14 (VSS XI0_I635_xbn XI0_I635_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I635_MN16 (XI0_I635_xn2 I0_B_5_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I635_MN15 (I0_pp2_22 XI0_I635_xan XI0_I635_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I635_MN13 (XI0_I635_xn1 XI0_I635_xn I0_pp2_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I635_MN2 (VSS I0_A_22_b3_0 XI0_I635_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I635_MN4 (XI0_I635_n2 I0_A_21_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I635_MN3 (XI0_I635_xn I0_two2_b3_4 XI0_I635_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I635_MN1 (XI0_I635_n1 I0_one2_b3_4 XI0_I635_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I635_MN9 (VSS XI0_I635_xn XI0_I635_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I690_MN11 (VSS I0_B_7_b3_3 XI0_I690_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I690_MN14 (VSS XI0_I690_xbn XI0_I690_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I690_MN16 (XI0_I690_xn2 I0_B_7_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I690_MN15 (I0_pp3_22 XI0_I690_xan XI0_I690_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I690_MN13 (XI0_I690_xn1 XI0_I690_xn I0_pp3_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I690_MN2 (VSS I0_A_22_b3_1 XI0_I690_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I690_MN4 (XI0_I690_n2 I0_A_21_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I690_MN3 (XI0_I690_xn I0_two3_b3_4 XI0_I690_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I690_MN1 (XI0_I690_n1 I0_one3_b3_4 XI0_I690_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I690_MN9 (VSS XI0_I690_xn XI0_I690_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I745_MN11 (VSS I0_B_9_b3_3 XI0_I745_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I745_MN14 (VSS XI0_I745_xbn XI0_I745_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I745_MN16 (XI0_I745_xn2 I0_B_9_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I745_MN15 (I0_pp4_22 XI0_I745_xan XI0_I745_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I745_MN13 (XI0_I745_xn1 XI0_I745_xn I0_pp4_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I745_MN2 (VSS I0_A_22_b3_1 XI0_I745_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I745_MN4 (XI0_I745_n2 I0_A_21_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I745_MN3 (XI0_I745_xn I0_two4_b3_4 XI0_I745_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I745_MN1 (XI0_I745_n1 I0_one4_b3_4 XI0_I745_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I745_MN9 (VSS XI0_I745_xn XI0_I745_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I692_MN11 (VSS I0_B_7_b3_4 XI0_I692_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I692_MN14 (VSS XI0_I692_xbn XI0_I692_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I692_MN16 (XI0_I692_xn2 I0_B_7_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I692_MN15 (I0_pp3_24 XI0_I692_xan XI0_I692_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I692_MN13 (XI0_I692_xn1 XI0_I692_xn I0_pp3_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I692_MN2 (VSS I0_A_24_b3_1 XI0_I692_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I692_MN4 (XI0_I692_n2 I0_A_23_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I692_MN3 (XI0_I692_xn I0_two3_b3_4 XI0_I692_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I692_MN1 (XI0_I692_n1 I0_one3_b3_4 XI0_I692_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I692_MN9 (VSS XI0_I692_xn XI0_I692_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I693_MN11 (VSS I0_B_7_b3_4 XI0_I693_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I693_MN14 (VSS XI0_I693_xbn XI0_I693_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I693_MN16 (XI0_I693_xn2 I0_B_7_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I693_MN15 (I0_pp3_25 XI0_I693_xan XI0_I693_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I693_MN13 (XI0_I693_xn1 XI0_I693_xn I0_pp3_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I693_MN2 (VSS I0_A_25_b3_1 XI0_I693_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I693_MN4 (XI0_I693_n2 I0_A_24_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I693_MN3 (XI0_I693_xn I0_two3_b3_4 XI0_I693_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I693_MN1 (XI0_I693_n1 I0_one3_b3_4 XI0_I693_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I693_MN9 (VSS XI0_I693_xn XI0_I693_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I694_MN11 (VSS I0_B_7_b3_4 XI0_I694_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I694_MN14 (VSS XI0_I694_xbn XI0_I694_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I694_MN16 (XI0_I694_xn2 I0_B_7_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I694_MN15 (I0_pp3_26 XI0_I694_xan XI0_I694_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I694_MN13 (XI0_I694_xn1 XI0_I694_xn I0_pp3_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I694_MN2 (VSS I0_A_26_b3_1 XI0_I694_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I694_MN4 (XI0_I694_n2 I0_A_25_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I694_MN3 (XI0_I694_xn I0_two3_b3_4 XI0_I694_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I694_MN1 (XI0_I694_n1 I0_one3_b3_4 XI0_I694_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I694_MN9 (VSS XI0_I694_xn XI0_I694_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I695_MN11 (VSS I0_B_7_b3_4 XI0_I695_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I695_MN14 (VSS XI0_I695_xbn XI0_I695_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I695_MN16 (XI0_I695_xn2 I0_B_7_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I695_MN15 (I0_pp3_27 XI0_I695_xan XI0_I695_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I695_MN13 (XI0_I695_xn1 XI0_I695_xn I0_pp3_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I695_MN2 (VSS I0_A_27_b3_1 XI0_I695_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I695_MN4 (XI0_I695_n2 I0_A_26_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I695_MN3 (XI0_I695_xn I0_two3_b3_4 XI0_I695_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I695_MN1 (XI0_I695_n1 I0_one3_b3_4 XI0_I695_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I695_MN9 (VSS XI0_I695_xn XI0_I695_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I516_MN11 (VSS I0_B_1_b3_2 XI0_I516_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I516_MN14 (VSS XI0_I516_xbn XI0_I516_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I516_MN16 (XI0_I516_xn2 I0_B_1_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I516_MN15 (I0_pp0_13 XI0_I516_xan XI0_I516_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I516_MN13 (XI0_I516_xn1 XI0_I516_xn I0_pp0_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I516_MN2 (VSS I0_A_13_b3_0 XI0_I516_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I516_MN4 (XI0_I516_n2 I0_A_12_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I516_MN3 (XI0_I516_xn I0_two0_b3_2 XI0_I516_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I516_MN1 (XI0_I516_n1 I0_one0_b3_2 XI0_I516_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I516_MN9 (VSS XI0_I516_xn XI0_I516_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I624_MN11 (VSS I0_B_5_b3_2 XI0_I624_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I624_MN14 (VSS XI0_I624_xbn XI0_I624_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I624_MN16 (XI0_I624_xn2 I0_B_5_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I624_MN15 (I0_pp2_11 XI0_I624_xan XI0_I624_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I624_MN13 (XI0_I624_xn1 XI0_I624_xn I0_pp2_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I624_MN2 (VSS I0_A_11_b3_0 XI0_I624_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I624_MN4 (XI0_I624_n2 I0_A_10_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I624_MN3 (XI0_I624_xn I0_two2_b3_2 XI0_I624_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I624_MN1 (XI0_I624_n1 I0_one2_b3_2 XI0_I624_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I624_MN9 (VSS XI0_I624_xn XI0_I624_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I573_MN11 (VSS I0_B_3_b3_2 XI0_I573_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I573_MN14 (VSS XI0_I573_xbn XI0_I573_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I573_MN16 (XI0_I573_xn2 I0_B_3_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I573_MN15 (I0_pp1_15 XI0_I573_xan XI0_I573_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I573_MN13 (XI0_I573_xn1 XI0_I573_xn I0_pp1_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I573_MN2 (VSS I0_A_15_b3_0 XI0_I573_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I573_MN4 (XI0_I573_n2 I0_A_14_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I573_MN3 (XI0_I573_xn I0_two1_b3_2 XI0_I573_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I573_MN1 (XI0_I573_n1 I0_one1_b3_2 XI0_I573_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I573_MN9 (VSS XI0_I573_xn XI0_I573_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I572_MN11 (VSS I0_B_3_b3_2 XI0_I572_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I572_MN14 (VSS XI0_I572_xbn XI0_I572_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I572_MN16 (XI0_I572_xn2 I0_B_3_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I572_MN15 (I0_pp1_14 XI0_I572_xan XI0_I572_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I572_MN13 (XI0_I572_xn1 XI0_I572_xn I0_pp1_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I572_MN2 (VSS I0_A_14_b3_0 XI0_I572_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I572_MN4 (XI0_I572_n2 I0_A_13_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I572_MN3 (XI0_I572_xn I0_two1_b3_2 XI0_I572_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I572_MN1 (XI0_I572_n1 I0_one1_b3_2 XI0_I572_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I572_MN9 (VSS XI0_I572_xn XI0_I572_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I627_MN11 (VSS I0_B_5_b3_2 XI0_I627_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I627_MN14 (VSS XI0_I627_xbn XI0_I627_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I627_MN16 (XI0_I627_xn2 I0_B_5_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I627_MN15 (I0_pp2_14 XI0_I627_xan XI0_I627_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I627_MN13 (XI0_I627_xn1 XI0_I627_xn I0_pp2_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I627_MN2 (VSS I0_A_14_b3_0 XI0_I627_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I627_MN4 (XI0_I627_n2 I0_A_13_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I627_MN3 (XI0_I627_xn I0_two2_b3_2 XI0_I627_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I627_MN1 (XI0_I627_n1 I0_one2_b3_2 XI0_I627_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I627_MN9 (VSS XI0_I627_xn XI0_I627_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I626_MN11 (VSS I0_B_5_b3_2 XI0_I626_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I626_MN14 (VSS XI0_I626_xbn XI0_I626_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I626_MN16 (XI0_I626_xn2 I0_B_5_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I626_MN15 (I0_pp2_13 XI0_I626_xan XI0_I626_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I626_MN13 (XI0_I626_xn1 XI0_I626_xn I0_pp2_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I626_MN2 (VSS I0_A_13_b3_0 XI0_I626_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I626_MN4 (XI0_I626_n2 I0_A_12_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I626_MN3 (XI0_I626_xn I0_two2_b3_2 XI0_I626_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I626_MN1 (XI0_I626_n1 I0_one2_b3_2 XI0_I626_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I626_MN9 (VSS XI0_I626_xn XI0_I626_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I628_MN11 (VSS I0_B_5_b3_2 XI0_I628_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I628_MN14 (VSS XI0_I628_xbn XI0_I628_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I628_MN16 (XI0_I628_xn2 I0_B_5_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I628_MN15 (I0_pp2_15 XI0_I628_xan XI0_I628_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I628_MN13 (XI0_I628_xn1 XI0_I628_xn I0_pp2_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I628_MN2 (VSS I0_A_15_b3_0 XI0_I628_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I628_MN4 (XI0_I628_n2 I0_A_14_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I628_MN3 (XI0_I628_xn I0_two2_b3_2 XI0_I628_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I628_MN1 (XI0_I628_n1 I0_one2_b3_2 XI0_I628_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I628_MN9 (VSS XI0_I628_xn XI0_I628_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I688_MN11 (VSS I0_B_7_b3_3 XI0_I688_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I688_MN14 (VSS XI0_I688_xbn XI0_I688_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I688_MN16 (XI0_I688_xn2 I0_B_7_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I688_MN15 (I0_pp3_20 XI0_I688_xan XI0_I688_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I688_MN13 (XI0_I688_xn1 XI0_I688_xn I0_pp3_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I688_MN2 (VSS I0_A_20_b3_1 XI0_I688_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I688_MN4 (XI0_I688_n2 I0_A_19_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I688_MN3 (XI0_I688_xn I0_two3_b3_3 XI0_I688_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I688_MN1 (XI0_I688_n1 I0_one3_b3_3 XI0_I688_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I688_MN9 (VSS XI0_I688_xn XI0_I688_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I689_MN11 (VSS I0_B_7_b3_3 XI0_I689_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I689_MN14 (VSS XI0_I689_xbn XI0_I689_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I689_MN16 (XI0_I689_xn2 I0_B_7_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I689_MN15 (I0_pp3_21 XI0_I689_xan XI0_I689_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I689_MN13 (XI0_I689_xn1 XI0_I689_xn I0_pp3_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I689_MN2 (VSS I0_A_21_b3_1 XI0_I689_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I689_MN4 (XI0_I689_n2 I0_A_20_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I689_MN3 (XI0_I689_xn I0_two3_b3_3 XI0_I689_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I689_MN1 (XI0_I689_n1 I0_one3_b3_3 XI0_I689_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I689_MN9 (VSS XI0_I689_xn XI0_I689_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I746_MN11 (VSS I0_B_9_b3_4 XI0_I746_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I746_MN14 (VSS XI0_I746_xbn XI0_I746_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I746_MN16 (XI0_I746_xn2 I0_B_9_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I746_MN15 (I0_pp4_23 XI0_I746_xan XI0_I746_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I746_MN13 (XI0_I746_xn1 XI0_I746_xn I0_pp4_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I746_MN2 (VSS I0_A_23_b3_1 XI0_I746_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I746_MN4 (XI0_I746_n2 I0_A_22_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I746_MN3 (XI0_I746_xn I0_two4_b3_4 XI0_I746_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I746_MN1 (XI0_I746_n1 I0_one4_b3_4 XI0_I746_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I746_MN9 (VSS XI0_I746_xn XI0_I746_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I691_MN11 (VSS I0_B_7_b3_4 XI0_I691_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I691_MN14 (VSS XI0_I691_xbn XI0_I691_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I691_MN16 (XI0_I691_xn2 I0_B_7_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I691_MN15 (I0_pp3_23 XI0_I691_xan XI0_I691_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I691_MN13 (XI0_I691_xn1 XI0_I691_xn I0_pp3_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I691_MN2 (VSS I0_A_23_b3_1 XI0_I691_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I691_MN4 (XI0_I691_n2 I0_A_22_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I691_MN3 (XI0_I691_xn I0_two3_b3_4 XI0_I691_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I691_MN1 (XI0_I691_n1 I0_one3_b3_4 XI0_I691_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I691_MN9 (VSS XI0_I691_xn XI0_I691_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I799_MN11 (VSS I0_B_11_b3_3 XI0_I799_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I799_MN14 (VSS XI0_I799_xbn XI0_I799_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I799_MN16 (XI0_I799_xn2 I0_B_11_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I799_MN15 (I0_pp5_21 XI0_I799_xan XI0_I799_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I799_MN13 (XI0_I799_xn1 XI0_I799_xn I0_pp5_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I799_MN2 (VSS I0_A_21_b3_1 XI0_I799_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I799_MN4 (XI0_I799_n2 I0_A_20_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I799_MN3 (XI0_I799_xn I0_two5_b3_3 XI0_I799_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I799_MN1 (XI0_I799_n1 I0_one5_b3_3 XI0_I799_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I799_MN9 (VSS XI0_I799_xn XI0_I799_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I747_MN11 (VSS I0_B_9_b3_4 XI0_I747_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I747_MN14 (VSS XI0_I747_xbn XI0_I747_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I747_MN16 (XI0_I747_xn2 I0_B_9_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I747_MN15 (I0_pp4_24 XI0_I747_xan XI0_I747_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I747_MN13 (XI0_I747_xn1 XI0_I747_xn I0_pp4_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I747_MN2 (VSS I0_A_24_b3_1 XI0_I747_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I747_MN4 (XI0_I747_n2 I0_A_23_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I747_MN3 (XI0_I747_xn I0_two4_b3_4 XI0_I747_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I747_MN1 (XI0_I747_n1 I0_one4_b3_4 XI0_I747_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I747_MN9 (VSS XI0_I747_xn XI0_I747_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I748_MN11 (VSS I0_B_9_b3_4 XI0_I748_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I748_MN14 (VSS XI0_I748_xbn XI0_I748_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I748_MN16 (XI0_I748_xn2 I0_B_9_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I748_MN15 (I0_pp4_25 XI0_I748_xan XI0_I748_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I748_MN13 (XI0_I748_xn1 XI0_I748_xn I0_pp4_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I748_MN2 (VSS I0_A_25_b3_1 XI0_I748_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I748_MN4 (XI0_I748_n2 I0_A_24_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I748_MN3 (XI0_I748_xn I0_two4_b3_4 XI0_I748_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I748_MN1 (XI0_I748_n1 I0_one4_b3_4 XI0_I748_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I748_MN9 (VSS XI0_I748_xn XI0_I748_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I750_MN11 (VSS I0_B_9_b3_4 XI0_I750_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I750_MN14 (VSS XI0_I750_xbn XI0_I750_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I750_MN16 (XI0_I750_xn2 I0_B_9_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I750_MN15 (I0_pp4_27 XI0_I750_xan XI0_I750_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I750_MN13 (XI0_I750_xn1 XI0_I750_xn I0_pp4_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I750_MN2 (VSS I0_A_27_b3_1 XI0_I750_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I750_MN4 (XI0_I750_n2 I0_A_26_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I750_MN3 (XI0_I750_xn I0_two4_b3_4 XI0_I750_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I750_MN1 (XI0_I750_n1 I0_one4_b3_4 XI0_I750_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I750_MN9 (VSS XI0_I750_xn XI0_I750_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I751_MN11 (VSS I0_B_9_b3_4 XI0_I751_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I751_MN14 (VSS XI0_I751_xbn XI0_I751_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I751_MN16 (XI0_I751_xn2 I0_B_9_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I751_MN15 (I0_pp4_28 XI0_I751_xan XI0_I751_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I751_MN13 (XI0_I751_xn1 XI0_I751_xn I0_pp4_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I751_MN2 (VSS I0_A_28_b3_1 XI0_I751_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I751_MN4 (XI0_I751_n2 I0_A_27_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I751_MN3 (XI0_I751_xn I0_two4_b3_5 XI0_I751_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I751_MN1 (XI0_I751_n1 I0_one4_b3_5 XI0_I751_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I751_MN9 (VSS XI0_I751_xn XI0_I751_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I752_MN11 (VSS I0_B_9_b3_5 XI0_I752_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I752_MN14 (VSS XI0_I752_xbn XI0_I752_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I752_MN16 (XI0_I752_xn2 I0_B_9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I752_MN15 (I0_pp4_29 XI0_I752_xan XI0_I752_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I752_MN13 (XI0_I752_xn1 XI0_I752_xn I0_pp4_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I752_MN2 (VSS I0_A_29_b3_1 XI0_I752_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I752_MN4 (XI0_I752_n2 I0_A_28_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I752_MN3 (XI0_I752_xn I0_two4_b3_5 XI0_I752_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I752_MN1 (XI0_I752_n1 I0_one4_b3_5 XI0_I752_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I752_MN9 (VSS XI0_I752_xn XI0_I752_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I753_MN11 (VSS I0_B_9_b3_5 XI0_I753_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I753_MN14 (VSS XI0_I753_xbn XI0_I753_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I753_MN16 (XI0_I753_xn2 I0_B_9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I753_MN15 (I0_pp4_30 XI0_I753_xan XI0_I753_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I753_MN13 (XI0_I753_xn1 XI0_I753_xn I0_pp4_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I753_MN2 (VSS I0_A_30_b3_1 XI0_I753_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I753_MN4 (XI0_I753_n2 I0_A_29_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I753_MN3 (XI0_I753_xn I0_two4_b3_5 XI0_I753_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I753_MN1 (XI0_I753_n1 I0_one4_b3_5 XI0_I753_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I753_MN9 (VSS XI0_I753_xn XI0_I753_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I754_MN11 (VSS I0_B_9_b3_5 XI0_I754_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I754_MN14 (VSS XI0_I754_xbn XI0_I754_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I754_MN16 (XI0_I754_xn2 I0_B_9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I754_MN15 (I0_pp4_31 XI0_I754_xan XI0_I754_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I754_MN13 (XI0_I754_xn1 XI0_I754_xn I0_pp4_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I754_MN2 (VSS I0_A_31_b3_2 XI0_I754_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I754_MN4 (XI0_I754_n2 I0_A_30_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I754_MN3 (XI0_I754_xn I0_two4_b3_5 XI0_I754_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I754_MN1 (XI0_I754_n1 I0_one4_b3_5 XI0_I754_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I754_MN9 (VSS XI0_I754_xn XI0_I754_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I755_MN11 (VSS I0_B_9_b3_5 XI0_I755_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I755_MN14 (VSS XI0_I755_xbn XI0_I755_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I755_MN16 (XI0_I755_xn2 I0_B_9_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I755_MN15 (I0_pp4_32 XI0_I755_xan XI0_I755_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I755_MN13 (XI0_I755_xn1 XI0_I755_xn I0_pp4_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I755_MN2 (VSS I0_A_31_b3_2 XI0_I755_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I755_MN4 (XI0_I755_n2 I0_A_31_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I755_MN3 (XI0_I755_xn I0_two4_b3_5 XI0_I755_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I755_MN1 (XI0_I755_n1 I0_one4_b3_5 XI0_I755_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I755_MN9 (VSS XI0_I755_xn XI0_I755_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I569_MN11 (VSS I0_B_3_b3_2 XI0_I569_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I569_MN14 (VSS XI0_I569_xbn XI0_I569_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I569_MN16 (XI0_I569_xn2 I0_B_3_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I569_MN15 (I0_pp1_11 XI0_I569_xan XI0_I569_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I569_MN13 (XI0_I569_xn1 XI0_I569_xn I0_pp1_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I569_MN2 (VSS I0_A_11_b3_0 XI0_I569_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I569_MN4 (XI0_I569_n2 I0_A_10_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I569_MN3 (XI0_I569_xn I0_two1_b3_2 XI0_I569_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I569_MN1 (XI0_I569_n1 I0_one1_b3_2 XI0_I569_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I569_MN9 (VSS XI0_I569_xn XI0_I569_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I515_MN11 (VSS I0_B_1_b3_2 XI0_I515_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I515_MN14 (VSS XI0_I515_xbn XI0_I515_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I515_MN16 (XI0_I515_xn2 I0_B_1_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I515_MN15 (I0_pp0_12 XI0_I515_xan XI0_I515_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I515_MN13 (XI0_I515_xn1 XI0_I515_xn I0_pp0_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I515_MN2 (VSS I0_A_12_b3_0 XI0_I515_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I515_MN4 (XI0_I515_n2 I0_A_11_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I515_MN3 (XI0_I515_xn I0_two0_b3_2 XI0_I515_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I515_MN1 (XI0_I515_n1 I0_one0_b3_2 XI0_I515_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I515_MN9 (VSS XI0_I515_xn XI0_I515_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I514_MN11 (VSS I0_B_1_b3_2 XI0_I514_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I514_MN14 (VSS XI0_I514_xbn XI0_I514_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I514_MN16 (XI0_I514_xn2 I0_B_1_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I514_MN15 (I0_pp0_11 XI0_I514_xan XI0_I514_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I514_MN13 (XI0_I514_xn1 XI0_I514_xn I0_pp0_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I514_MN2 (VSS I0_A_11_b3_0 XI0_I514_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I514_MN4 (XI0_I514_n2 I0_A_10_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I514_MN3 (XI0_I514_xn I0_two0_b3_2 XI0_I514_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I514_MN1 (XI0_I514_n1 I0_one0_b3_2 XI0_I514_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I514_MN9 (VSS XI0_I514_xn XI0_I514_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I517_MN11 (VSS I0_B_1_b3_2 XI0_I517_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I517_MN14 (VSS XI0_I517_xbn XI0_I517_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I517_MN16 (XI0_I517_xn2 I0_B_1_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I517_MN15 (I0_pp0_14 XI0_I517_xan XI0_I517_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I517_MN13 (XI0_I517_xn1 XI0_I517_xn I0_pp0_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I517_MN2 (VSS I0_A_14_b3_0 XI0_I517_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I517_MN4 (XI0_I517_n2 I0_A_13_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I517_MN3 (XI0_I517_xn I0_two0_b3_2 XI0_I517_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I517_MN1 (XI0_I517_n1 I0_one0_b3_2 XI0_I517_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I517_MN9 (VSS XI0_I517_xn XI0_I517_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I571_MN11 (VSS I0_B_3_b3_2 XI0_I571_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I571_MN14 (VSS XI0_I571_xbn XI0_I571_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I571_MN16 (XI0_I571_xn2 I0_B_3_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I571_MN15 (I0_pp1_13 XI0_I571_xan XI0_I571_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I571_MN13 (XI0_I571_xn1 XI0_I571_xn I0_pp1_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I571_MN2 (VSS I0_A_13_b3_0 XI0_I571_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I571_MN4 (XI0_I571_n2 I0_A_12_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I571_MN3 (XI0_I571_xn I0_two1_b3_2 XI0_I571_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I571_MN1 (XI0_I571_n1 I0_one1_b3_2 XI0_I571_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I571_MN9 (VSS XI0_I571_xn XI0_I571_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I518_MN11 (VSS I0_B_1_b3_2 XI0_I518_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I518_MN14 (VSS XI0_I518_xbn XI0_I518_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I518_MN16 (XI0_I518_xn2 I0_B_1_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I518_MN15 (I0_pp0_15 XI0_I518_xan XI0_I518_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I518_MN13 (XI0_I518_xn1 XI0_I518_xn I0_pp0_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I518_MN2 (VSS I0_A_15_b3_0 XI0_I518_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I518_MN4 (XI0_I518_n2 I0_A_14_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I518_MN3 (XI0_I518_xn I0_two0_b3_2 XI0_I518_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I518_MN1 (XI0_I518_n1 I0_one0_b3_2 XI0_I518_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I518_MN9 (VSS XI0_I518_xn XI0_I518_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I570_MN11 (VSS I0_B_3_b3_2 XI0_I570_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I570_MN14 (VSS XI0_I570_xbn XI0_I570_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I570_MN16 (XI0_I570_xn2 I0_B_3_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I570_MN15 (I0_pp1_12 XI0_I570_xan XI0_I570_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I570_MN13 (XI0_I570_xn1 XI0_I570_xn I0_pp1_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I570_MN2 (VSS I0_A_12_b3_0 XI0_I570_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I570_MN4 (XI0_I570_n2 I0_A_11_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I570_MN3 (XI0_I570_xn I0_two1_b3_2 XI0_I570_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I570_MN1 (XI0_I570_n1 I0_one1_b3_2 XI0_I570_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I570_MN9 (VSS XI0_I570_xn XI0_I570_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I625_MN11 (VSS I0_B_5_b3_2 XI0_I625_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I625_MN14 (VSS XI0_I625_xbn XI0_I625_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I625_MN16 (XI0_I625_xn2 I0_B_5_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I625_MN15 (I0_pp2_12 XI0_I625_xan XI0_I625_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I625_MN13 (XI0_I625_xn1 XI0_I625_xn I0_pp2_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I625_MN2 (VSS I0_A_12_b3_0 XI0_I625_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I625_MN4 (XI0_I625_n2 I0_A_11_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I625_MN3 (XI0_I625_xn I0_two2_b3_2 XI0_I625_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I625_MN1 (XI0_I625_n1 I0_one2_b3_2 XI0_I625_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I625_MN9 (VSS XI0_I625_xn XI0_I625_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I679_MN11 (VSS I0_B_7_b3_2 XI0_I679_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I679_MN14 (VSS XI0_I679_xbn XI0_I679_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I679_MN16 (XI0_I679_xn2 I0_B_7_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I679_MN15 (I0_pp3_11 XI0_I679_xan XI0_I679_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I679_MN13 (XI0_I679_xn1 XI0_I679_xn I0_pp3_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I679_MN2 (VSS I0_A_11_b3_1 XI0_I679_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I679_MN4 (XI0_I679_n2 I0_A_10_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I679_MN3 (XI0_I679_xn I0_two3_b3_2 XI0_I679_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I679_MN1 (XI0_I679_n1 I0_one3_b3_2 XI0_I679_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I679_MN9 (VSS XI0_I679_xn XI0_I679_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I680_MN11 (VSS I0_B_7_b3_2 XI0_I680_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I680_MN14 (VSS XI0_I680_xbn XI0_I680_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I680_MN16 (XI0_I680_xn2 I0_B_7_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I680_MN15 (I0_pp3_12 XI0_I680_xan XI0_I680_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I680_MN13 (XI0_I680_xn1 XI0_I680_xn I0_pp3_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I680_MN2 (VSS I0_A_12_b3_1 XI0_I680_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I680_MN4 (XI0_I680_n2 I0_A_11_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I680_MN3 (XI0_I680_xn I0_two3_b3_2 XI0_I680_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I680_MN1 (XI0_I680_n1 I0_one3_b3_2 XI0_I680_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I680_MN9 (VSS XI0_I680_xn XI0_I680_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I682_MN11 (VSS I0_B_7_b3_2 XI0_I682_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I682_MN14 (VSS XI0_I682_xbn XI0_I682_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I682_MN16 (XI0_I682_xn2 I0_B_7_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I682_MN15 (I0_pp3_14 XI0_I682_xan XI0_I682_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I682_MN13 (XI0_I682_xn1 XI0_I682_xn I0_pp3_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I682_MN2 (VSS I0_A_14_b3_1 XI0_I682_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I682_MN4 (XI0_I682_n2 I0_A_13_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I682_MN3 (XI0_I682_xn I0_two3_b3_2 XI0_I682_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I682_MN1 (XI0_I682_n1 I0_one3_b3_2 XI0_I682_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I682_MN9 (VSS XI0_I682_xn XI0_I682_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I681_MN11 (VSS I0_B_7_b3_2 XI0_I681_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I681_MN14 (VSS XI0_I681_xbn XI0_I681_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I681_MN16 (XI0_I681_xn2 I0_B_7_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I681_MN15 (I0_pp3_13 XI0_I681_xan XI0_I681_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I681_MN13 (XI0_I681_xn1 XI0_I681_xn I0_pp3_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I681_MN2 (VSS I0_A_13_b3_1 XI0_I681_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I681_MN4 (XI0_I681_n2 I0_A_12_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I681_MN3 (XI0_I681_xn I0_two3_b3_2 XI0_I681_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I681_MN1 (XI0_I681_n1 I0_one3_b3_2 XI0_I681_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I681_MN9 (VSS XI0_I681_xn XI0_I681_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I683_MN11 (VSS I0_B_7_b3_2 XI0_I683_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I683_MN14 (VSS XI0_I683_xbn XI0_I683_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I683_MN16 (XI0_I683_xn2 I0_B_7_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I683_MN15 (I0_pp3_15 XI0_I683_xan XI0_I683_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I683_MN13 (XI0_I683_xn1 XI0_I683_xn I0_pp3_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I683_MN2 (VSS I0_A_15_b3_1 XI0_I683_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I683_MN4 (XI0_I683_n2 I0_A_14_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I683_MN3 (XI0_I683_xn I0_two3_b3_2 XI0_I683_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I683_MN1 (XI0_I683_n1 I0_one3_b3_2 XI0_I683_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I683_MN9 (VSS XI0_I683_xn XI0_I683_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I684_MN11 (VSS I0_B_7_b3_2 XI0_I684_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I684_MN14 (VSS XI0_I684_xbn XI0_I684_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I684_MN16 (XI0_I684_xn2 I0_B_7_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I684_MN15 (I0_pp3_16 XI0_I684_xan XI0_I684_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I684_MN13 (XI0_I684_xn1 XI0_I684_xn I0_pp3_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I684_MN2 (VSS I0_A_16_b3_1 XI0_I684_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I684_MN4 (XI0_I684_n2 I0_A_15_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I684_MN3 (XI0_I684_xn I0_two3_b3_2 XI0_I684_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I684_MN1 (XI0_I684_n1 I0_one3_b3_2 XI0_I684_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I684_MN9 (VSS XI0_I684_xn XI0_I684_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I687_MN11 (VSS I0_B_7_b3_3 XI0_I687_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I687_MN14 (VSS XI0_I687_xbn XI0_I687_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I687_MN16 (XI0_I687_xn2 I0_B_7_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I687_MN15 (I0_pp3_19 XI0_I687_xan XI0_I687_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I687_MN13 (XI0_I687_xn1 XI0_I687_xn I0_pp3_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I687_MN2 (VSS I0_A_19_b3_1 XI0_I687_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I687_MN4 (XI0_I687_n2 I0_A_18_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I687_MN3 (XI0_I687_xn I0_two3_b3_3 XI0_I687_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I687_MN1 (XI0_I687_n1 I0_one3_b3_3 XI0_I687_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I687_MN9 (VSS XI0_I687_xn XI0_I687_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I685_MN11 (VSS I0_B_7_b3_3 XI0_I685_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I685_MN14 (VSS XI0_I685_xbn XI0_I685_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I685_MN16 (XI0_I685_xn2 I0_B_7_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I685_MN15 (I0_pp3_17 XI0_I685_xan XI0_I685_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I685_MN13 (XI0_I685_xn1 XI0_I685_xn I0_pp3_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I685_MN2 (VSS I0_A_17_b3_1 XI0_I685_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I685_MN4 (XI0_I685_n2 I0_A_16_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I685_MN3 (XI0_I685_xn I0_two3_b3_3 XI0_I685_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I685_MN1 (XI0_I685_n1 I0_one3_b3_3 XI0_I685_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I685_MN9 (VSS XI0_I685_xn XI0_I685_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I686_MN11 (VSS I0_B_7_b3_3 XI0_I686_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I686_MN14 (VSS XI0_I686_xbn XI0_I686_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I686_MN16 (XI0_I686_xn2 I0_B_7_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I686_MN15 (I0_pp3_18 XI0_I686_xan XI0_I686_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I686_MN13 (XI0_I686_xn1 XI0_I686_xn I0_pp3_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I686_MN2 (VSS I0_A_18_b3_1 XI0_I686_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I686_MN4 (XI0_I686_n2 I0_A_17_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I686_MN3 (XI0_I686_xn I0_two3_b3_3 XI0_I686_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I686_MN1 (XI0_I686_n1 I0_one3_b3_3 XI0_I686_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I686_MN9 (VSS XI0_I686_xn XI0_I686_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I744_MN11 (VSS I0_B_9_b3_3 XI0_I744_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I744_MN14 (VSS XI0_I744_xbn XI0_I744_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I744_MN16 (XI0_I744_xn2 I0_B_9_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I744_MN15 (I0_pp4_21 XI0_I744_xan XI0_I744_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I744_MN13 (XI0_I744_xn1 XI0_I744_xn I0_pp4_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I744_MN2 (VSS I0_A_21_b3_1 XI0_I744_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I744_MN4 (XI0_I744_n2 I0_A_20_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I744_MN3 (XI0_I744_xn I0_two4_b3_3 XI0_I744_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I744_MN1 (XI0_I744_n1 I0_one4_b3_3 XI0_I744_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I744_MN9 (VSS XI0_I744_xn XI0_I744_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I795_MN11 (VSS I0_B_11_b3_3 XI0_I795_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I795_MN14 (VSS XI0_I795_xbn XI0_I795_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I795_MN16 (XI0_I795_xn2 I0_B_11_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I795_MN15 (I0_pp5_17 XI0_I795_xan XI0_I795_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I795_MN13 (XI0_I795_xn1 XI0_I795_xn I0_pp5_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I795_MN2 (VSS I0_A_17_b3_1 XI0_I795_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I795_MN4 (XI0_I795_n2 I0_A_16_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I795_MN3 (XI0_I795_xn I0_two5_b3_3 XI0_I795_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I795_MN1 (XI0_I795_n1 I0_one5_b3_3 XI0_I795_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I795_MN9 (VSS XI0_I795_xn XI0_I795_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I798_MN11 (VSS I0_B_11_b3_3 XI0_I798_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I798_MN14 (VSS XI0_I798_xbn XI0_I798_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I798_MN16 (XI0_I798_xn2 I0_B_11_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I798_MN15 (I0_pp5_20 XI0_I798_xan XI0_I798_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I798_MN13 (XI0_I798_xn1 XI0_I798_xn I0_pp5_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I798_MN2 (VSS I0_A_20_b3_1 XI0_I798_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I798_MN4 (XI0_I798_n2 I0_A_19_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I798_MN3 (XI0_I798_xn I0_two5_b3_3 XI0_I798_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I798_MN1 (XI0_I798_n1 I0_one5_b3_3 XI0_I798_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I798_MN9 (VSS XI0_I798_xn XI0_I798_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I851_MN11 (VSS I0_B_13_b3_3 XI0_I851_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I851_MN14 (VSS XI0_I851_xbn XI0_I851_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I851_MN16 (XI0_I851_xn2 I0_B_13_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I851_MN15 (I0_pp6_18 XI0_I851_xan XI0_I851_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I851_MN13 (XI0_I851_xn1 XI0_I851_xn I0_pp6_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I851_MN2 (VSS I0_A_18_b3_2 XI0_I851_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I851_MN4 (XI0_I851_n2 I0_A_17_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I851_MN3 (XI0_I851_xn I0_two6_b3_3 XI0_I851_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I851_MN1 (XI0_I851_n1 I0_one6_b3_3 XI0_I851_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I851_MN9 (VSS XI0_I851_xn XI0_I851_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I800_MN11 (VSS I0_B_11_b3_3 XI0_I800_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I800_MN14 (VSS XI0_I800_xbn XI0_I800_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I800_MN16 (XI0_I800_xn2 I0_B_11_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I800_MN15 (I0_pp5_22 XI0_I800_xan XI0_I800_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I800_MN13 (XI0_I800_xn1 XI0_I800_xn I0_pp5_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I800_MN2 (VSS I0_A_22_b3_1 XI0_I800_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I800_MN4 (XI0_I800_n2 I0_A_21_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I800_MN3 (XI0_I800_xn I0_two5_b3_4 XI0_I800_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I800_MN1 (XI0_I800_n1 I0_one5_b3_4 XI0_I800_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I800_MN9 (VSS XI0_I800_xn XI0_I800_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I853_MN11 (VSS I0_B_13_b3_3 XI0_I853_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I853_MN14 (VSS XI0_I853_xbn XI0_I853_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I853_MN16 (XI0_I853_xn2 I0_B_13_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I853_MN15 (I0_pp6_20 XI0_I853_xan XI0_I853_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I853_MN13 (XI0_I853_xn1 XI0_I853_xn I0_pp6_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I853_MN2 (VSS I0_A_20_b3_2 XI0_I853_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I853_MN4 (XI0_I853_n2 I0_A_19_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I853_MN3 (XI0_I853_xn I0_two6_b3_3 XI0_I853_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I853_MN1 (XI0_I853_n1 I0_one6_b3_3 XI0_I853_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I853_MN9 (VSS XI0_I853_xn XI0_I853_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I905_MN11 (VSS I0_B_15_b3_3 XI0_I905_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I905_MN14 (VSS XI0_I905_xbn XI0_I905_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I905_MN16 (XI0_I905_xn2 I0_B_15_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I905_MN15 (I0_pp7_17 XI0_I905_xan XI0_I905_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I905_MN13 (XI0_I905_xn1 XI0_I905_xn I0_pp7_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I905_MN2 (VSS I0_A_17_b3_2 XI0_I905_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I905_MN4 (XI0_I905_n2 I0_A_16_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I905_MN3 (XI0_I905_xn I0_two7_b3_3 XI0_I905_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I905_MN1 (XI0_I905_n1 I0_one7_b3_3 XI0_I905_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I905_MN9 (VSS XI0_I905_xn XI0_I905_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I801_MN11 (VSS I0_B_11_b3_4 XI0_I801_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I801_MN14 (VSS XI0_I801_xbn XI0_I801_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I801_MN16 (XI0_I801_xn2 I0_B_11_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I801_MN15 (I0_pp5_23 XI0_I801_xan XI0_I801_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I801_MN13 (XI0_I801_xn1 XI0_I801_xn I0_pp5_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I801_MN2 (VSS I0_A_23_b3_1 XI0_I801_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I801_MN4 (XI0_I801_n2 I0_A_22_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I801_MN3 (XI0_I801_xn I0_two5_b3_4 XI0_I801_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I801_MN1 (XI0_I801_n1 I0_one5_b3_4 XI0_I801_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I801_MN9 (VSS XI0_I801_xn XI0_I801_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I749_MN11 (VSS I0_B_9_b3_4 XI0_I749_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I749_MN14 (VSS XI0_I749_xbn XI0_I749_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I749_MN16 (XI0_I749_xn2 I0_B_9_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I749_MN15 (I0_pp4_26 XI0_I749_xan XI0_I749_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I749_MN13 (XI0_I749_xn1 XI0_I749_xn I0_pp4_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I749_MN2 (VSS I0_A_26_b3_1 XI0_I749_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I749_MN4 (XI0_I749_n2 I0_A_25_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I749_MN3 (XI0_I749_xn I0_two4_b3_4 XI0_I749_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I749_MN1 (XI0_I749_n1 I0_one4_b3_4 XI0_I749_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I749_MN9 (VSS XI0_I749_xn XI0_I749_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I804_MN11 (VSS I0_B_11_b3_4 XI0_I804_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I804_MN14 (VSS XI0_I804_xbn XI0_I804_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I804_MN16 (XI0_I804_xn2 I0_B_11_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I804_MN15 (I0_pp5_26 XI0_I804_xan XI0_I804_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I804_MN13 (XI0_I804_xn1 XI0_I804_xn I0_pp5_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I804_MN2 (VSS I0_A_26_b3_1 XI0_I804_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I804_MN4 (XI0_I804_n2 I0_A_25_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I804_MN3 (XI0_I804_xn I0_two5_b3_4 XI0_I804_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I804_MN1 (XI0_I804_n1 I0_one5_b3_4 XI0_I804_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I804_MN9 (VSS XI0_I804_xn XI0_I804_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I802_MN11 (VSS I0_B_11_b3_4 XI0_I802_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I802_MN14 (VSS XI0_I802_xbn XI0_I802_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I802_MN16 (XI0_I802_xn2 I0_B_11_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I802_MN15 (I0_pp5_24 XI0_I802_xan XI0_I802_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I802_MN13 (XI0_I802_xn1 XI0_I802_xn I0_pp5_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I802_MN2 (VSS I0_A_24_b3_1 XI0_I802_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I802_MN4 (XI0_I802_n2 I0_A_23_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I802_MN3 (XI0_I802_xn I0_two5_b3_4 XI0_I802_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I802_MN1 (XI0_I802_n1 I0_one5_b3_4 XI0_I802_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I802_MN9 (VSS XI0_I802_xn XI0_I802_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I805_MN11 (VSS I0_B_11_b3_4 XI0_I805_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I805_MN14 (VSS XI0_I805_xbn XI0_I805_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I805_MN16 (XI0_I805_xn2 I0_B_11_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I805_MN15 (I0_pp5_27 XI0_I805_xan XI0_I805_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I805_MN13 (XI0_I805_xn1 XI0_I805_xn I0_pp5_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I805_MN2 (VSS I0_A_27_b3_1 XI0_I805_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I805_MN4 (XI0_I805_n2 I0_A_26_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I805_MN3 (XI0_I805_xn I0_two5_b3_4 XI0_I805_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I805_MN1 (XI0_I805_n1 I0_one5_b3_4 XI0_I805_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I805_MN9 (VSS XI0_I805_xn XI0_I805_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I803_MN11 (VSS I0_B_11_b3_4 XI0_I803_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I803_MN14 (VSS XI0_I803_xbn XI0_I803_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I803_MN16 (XI0_I803_xn2 I0_B_11_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I803_MN15 (I0_pp5_25 XI0_I803_xan XI0_I803_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I803_MN13 (XI0_I803_xn1 XI0_I803_xn I0_pp5_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I803_MN2 (VSS I0_A_25_b3_1 XI0_I803_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I803_MN4 (XI0_I803_n2 I0_A_24_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I803_MN3 (XI0_I803_xn I0_two5_b3_4 XI0_I803_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I803_MN1 (XI0_I803_n1 I0_one5_b3_4 XI0_I803_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I803_MN9 (VSS XI0_I803_xn XI0_I803_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I806_MN11 (VSS I0_B_11_b3_4 XI0_I806_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I806_MN14 (VSS XI0_I806_xbn XI0_I806_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I806_MN16 (XI0_I806_xn2 I0_B_11_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I806_MN15 (I0_pp5_28 XI0_I806_xan XI0_I806_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I806_MN13 (XI0_I806_xn1 XI0_I806_xn I0_pp5_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I806_MN2 (VSS I0_A_28_b3_1 XI0_I806_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I806_MN4 (XI0_I806_n2 I0_A_27_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I806_MN3 (XI0_I806_xn I0_two5_b3_5 XI0_I806_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I806_MN1 (XI0_I806_n1 I0_one5_b3_5 XI0_I806_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I806_MN9 (VSS XI0_I806_xn XI0_I806_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I807_MN11 (VSS I0_B_11_b3_5 XI0_I807_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I807_MN14 (VSS XI0_I807_xbn XI0_I807_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I807_MN16 (XI0_I807_xn2 I0_B_11_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I807_MN15 (I0_pp5_29 XI0_I807_xan XI0_I807_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I807_MN13 (XI0_I807_xn1 XI0_I807_xn I0_pp5_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I807_MN2 (VSS I0_A_29_b3_1 XI0_I807_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I807_MN4 (XI0_I807_n2 I0_A_28_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I807_MN3 (XI0_I807_xn I0_two5_b3_5 XI0_I807_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I807_MN1 (XI0_I807_n1 I0_one5_b3_5 XI0_I807_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I807_MN9 (VSS XI0_I807_xn XI0_I807_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I810_MN11 (VSS I0_B_11_b3_5 XI0_I810_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I810_MN14 (VSS XI0_I810_xbn XI0_I810_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I810_MN16 (XI0_I810_xn2 I0_B_11_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I810_MN15 (I0_pp5_32 XI0_I810_xan XI0_I810_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I810_MN13 (XI0_I810_xn1 XI0_I810_xn I0_pp5_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I810_MN2 (VSS I0_A_31_b3_2 XI0_I810_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I810_MN4 (XI0_I810_n2 I0_A_31_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I810_MN3 (XI0_I810_xn I0_two5_b3_5 XI0_I810_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I810_MN1 (XI0_I810_n1 I0_one5_b3_5 XI0_I810_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I810_MN9 (VSS XI0_I810_xn XI0_I810_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I623_MN11 (VSS I0_B_5_b3_1 XI0_I623_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I623_MN14 (VSS XI0_I623_xbn XI0_I623_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I623_MN16 (XI0_I623_xn2 I0_B_5_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I623_MN15 (I0_pp2_10 XI0_I623_xan XI0_I623_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I623_MN13 (XI0_I623_xn1 XI0_I623_xn I0_pp2_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I623_MN2 (VSS I0_A_10_b3_0 XI0_I623_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I623_MN4 (XI0_I623_n2 I0_A_9_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I623_MN3 (XI0_I623_xn I0_two2_b3_1 XI0_I623_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I623_MN1 (XI0_I623_n1 I0_one2_b3_1 XI0_I623_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I623_MN9 (VSS XI0_I623_xn XI0_I623_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I519_MN11 (VSS I0_B_1_b3_2 XI0_I519_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I519_MN14 (VSS XI0_I519_xbn XI0_I519_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I519_MN16 (XI0_I519_xn2 I0_B_1_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I519_MN15 (I0_pp0_16 XI0_I519_xan XI0_I519_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I519_MN13 (XI0_I519_xn1 XI0_I519_xn I0_pp0_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I519_MN2 (VSS I0_A_16_b3_0 XI0_I519_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I519_MN4 (XI0_I519_n2 I0_A_15_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I519_MN3 (XI0_I519_xn I0_two0_b3_2 XI0_I519_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I519_MN1 (XI0_I519_n1 I0_one0_b3_2 XI0_I519_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I519_MN9 (VSS XI0_I519_xn XI0_I519_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I794_MN11 (VSS I0_B_11_b3_2 XI0_I794_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I794_MN14 (VSS XI0_I794_xbn XI0_I794_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I794_MN16 (XI0_I794_xn2 I0_B_11_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I794_MN15 (I0_pp5_16 XI0_I794_xan XI0_I794_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I794_MN13 (XI0_I794_xn1 XI0_I794_xn I0_pp5_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I794_MN2 (VSS I0_A_16_b3_1 XI0_I794_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I794_MN4 (XI0_I794_n2 I0_A_15_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I794_MN3 (XI0_I794_xn I0_two5_b3_2 XI0_I794_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I794_MN1 (XI0_I794_n1 I0_one5_b3_2 XI0_I794_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I794_MN9 (VSS XI0_I794_xn XI0_I794_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I900_MN11 (VSS I0_B_15_b3_2 XI0_I900_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I900_MN14 (VSS XI0_I900_xbn XI0_I900_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I900_MN16 (XI0_I900_xn2 I0_B_15_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I900_MN15 (I0_pp7_12 XI0_I900_xan XI0_I900_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I900_MN13 (XI0_I900_xn1 XI0_I900_xn I0_pp7_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I900_MN2 (VSS I0_A_12_b3_2 XI0_I900_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I900_MN4 (XI0_I900_n2 I0_A_11_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I900_MN3 (XI0_I900_xn I0_two7_b3_2 XI0_I900_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I900_MN1 (XI0_I900_n1 I0_one7_b3_2 XI0_I900_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I900_MN9 (VSS XI0_I900_xn XI0_I900_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I902_MN11 (VSS I0_B_15_b3_2 XI0_I902_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I902_MN14 (VSS XI0_I902_xbn XI0_I902_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I902_MN16 (XI0_I902_xn2 I0_B_15_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I902_MN15 (I0_pp7_14 XI0_I902_xan XI0_I902_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I902_MN13 (XI0_I902_xn1 XI0_I902_xn I0_pp7_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I902_MN2 (VSS I0_A_14_b3_2 XI0_I902_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I902_MN4 (XI0_I902_n2 I0_A_13_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I902_MN3 (XI0_I902_xn I0_two7_b3_2 XI0_I902_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I902_MN1 (XI0_I902_n1 I0_one7_b3_2 XI0_I902_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I902_MN9 (VSS XI0_I902_xn XI0_I902_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I904_MN11 (VSS I0_B_15_b3_2 XI0_I904_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I904_MN14 (VSS XI0_I904_xbn XI0_I904_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I904_MN16 (XI0_I904_xn2 I0_B_15_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I904_MN15 (I0_pp7_16 XI0_I904_xan XI0_I904_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I904_MN13 (XI0_I904_xn1 XI0_I904_xn I0_pp7_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I904_MN2 (VSS I0_A_16_b3_2 XI0_I904_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I904_MN4 (XI0_I904_n2 I0_A_15_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I904_MN3 (XI0_I904_xn I0_two7_b3_2 XI0_I904_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I904_MN1 (XI0_I904_n1 I0_one7_b3_2 XI0_I904_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I904_MN9 (VSS XI0_I904_xn XI0_I904_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I903_MN11 (VSS I0_B_15_b3_2 XI0_I903_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I903_MN14 (VSS XI0_I903_xbn XI0_I903_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I903_MN16 (XI0_I903_xn2 I0_B_15_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I903_MN15 (I0_pp7_15 XI0_I903_xan XI0_I903_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I903_MN13 (XI0_I903_xn1 XI0_I903_xn I0_pp7_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I903_MN2 (VSS I0_A_15_b3_2 XI0_I903_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I903_MN4 (XI0_I903_n2 I0_A_14_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I903_MN3 (XI0_I903_xn I0_two7_b3_2 XI0_I903_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I903_MN1 (XI0_I903_n1 I0_one7_b3_2 XI0_I903_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I903_MN9 (VSS XI0_I903_xn XI0_I903_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I740_MN11 (VSS I0_B_9_b3_3 XI0_I740_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I740_MN14 (VSS XI0_I740_xbn XI0_I740_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I740_MN16 (XI0_I740_xn2 I0_B_9_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I740_MN15 (I0_pp4_17 XI0_I740_xan XI0_I740_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I740_MN13 (XI0_I740_xn1 XI0_I740_xn I0_pp4_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I740_MN2 (VSS I0_A_17_b3_1 XI0_I740_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I740_MN4 (XI0_I740_n2 I0_A_16_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I740_MN3 (XI0_I740_xn I0_two4_b3_3 XI0_I740_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I740_MN1 (XI0_I740_n1 I0_one4_b3_3 XI0_I740_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I740_MN9 (VSS XI0_I740_xn XI0_I740_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I742_MN11 (VSS I0_B_9_b3_3 XI0_I742_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I742_MN14 (VSS XI0_I742_xbn XI0_I742_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I742_MN16 (XI0_I742_xn2 I0_B_9_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I742_MN15 (I0_pp4_19 XI0_I742_xan XI0_I742_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I742_MN13 (XI0_I742_xn1 XI0_I742_xn I0_pp4_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I742_MN2 (VSS I0_A_19_b3_1 XI0_I742_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I742_MN4 (XI0_I742_n2 I0_A_18_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I742_MN3 (XI0_I742_xn I0_two4_b3_3 XI0_I742_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I742_MN1 (XI0_I742_n1 I0_one4_b3_3 XI0_I742_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I742_MN9 (VSS XI0_I742_xn XI0_I742_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I741_MN11 (VSS I0_B_9_b3_3 XI0_I741_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I741_MN14 (VSS XI0_I741_xbn XI0_I741_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I741_MN16 (XI0_I741_xn2 I0_B_9_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I741_MN15 (I0_pp4_18 XI0_I741_xan XI0_I741_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I741_MN13 (XI0_I741_xn1 XI0_I741_xn I0_pp4_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I741_MN2 (VSS I0_A_18_b3_1 XI0_I741_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I741_MN4 (XI0_I741_n2 I0_A_17_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I741_MN3 (XI0_I741_xn I0_two4_b3_3 XI0_I741_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I741_MN1 (XI0_I741_n1 I0_one4_b3_3 XI0_I741_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I741_MN9 (VSS XI0_I741_xn XI0_I741_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I743_MN11 (VSS I0_B_9_b3_3 XI0_I743_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I743_MN14 (VSS XI0_I743_xbn XI0_I743_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I743_MN16 (XI0_I743_xn2 I0_B_9_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I743_MN15 (I0_pp4_20 XI0_I743_xan XI0_I743_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I743_MN13 (XI0_I743_xn1 XI0_I743_xn I0_pp4_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I743_MN2 (VSS I0_A_20_b3_1 XI0_I743_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I743_MN4 (XI0_I743_n2 I0_A_19_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I743_MN3 (XI0_I743_xn I0_two4_b3_3 XI0_I743_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I743_MN1 (XI0_I743_n1 I0_one4_b3_3 XI0_I743_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I743_MN9 (VSS XI0_I743_xn XI0_I743_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I797_MN11 (VSS I0_B_11_b3_3 XI0_I797_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I797_MN14 (VSS XI0_I797_xbn XI0_I797_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I797_MN16 (XI0_I797_xn2 I0_B_11_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I797_MN15 (I0_pp5_19 XI0_I797_xan XI0_I797_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I797_MN13 (XI0_I797_xn1 XI0_I797_xn I0_pp5_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I797_MN2 (VSS I0_A_19_b3_1 XI0_I797_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I797_MN4 (XI0_I797_n2 I0_A_18_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I797_MN3 (XI0_I797_xn I0_two5_b3_3 XI0_I797_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I797_MN1 (XI0_I797_n1 I0_one5_b3_3 XI0_I797_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I797_MN9 (VSS XI0_I797_xn XI0_I797_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I796_MN11 (VSS I0_B_11_b3_3 XI0_I796_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I796_MN14 (VSS XI0_I796_xbn XI0_I796_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I796_MN16 (XI0_I796_xn2 I0_B_11_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I796_MN15 (I0_pp5_18 XI0_I796_xan XI0_I796_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I796_MN13 (XI0_I796_xn1 XI0_I796_xn I0_pp5_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I796_MN2 (VSS I0_A_18_b3_1 XI0_I796_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I796_MN4 (XI0_I796_n2 I0_A_17_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I796_MN3 (XI0_I796_xn I0_two5_b3_3 XI0_I796_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I796_MN1 (XI0_I796_n1 I0_one5_b3_3 XI0_I796_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I796_MN9 (VSS XI0_I796_xn XI0_I796_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I850_MN11 (VSS I0_B_13_b3_3 XI0_I850_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I850_MN14 (VSS XI0_I850_xbn XI0_I850_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I850_MN16 (XI0_I850_xn2 I0_B_13_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I850_MN15 (I0_pp6_17 XI0_I850_xan XI0_I850_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I850_MN13 (XI0_I850_xn1 XI0_I850_xn I0_pp6_17 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I850_MN2 (VSS I0_A_17_b3_2 XI0_I850_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I850_MN4 (XI0_I850_n2 I0_A_16_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I850_MN3 (XI0_I850_xn I0_two6_b3_3 XI0_I850_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I850_MN1 (XI0_I850_n1 I0_one6_b3_3 XI0_I850_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I850_MN9 (VSS XI0_I850_xn XI0_I850_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I852_MN11 (VSS I0_B_13_b3_3 XI0_I852_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I852_MN14 (VSS XI0_I852_xbn XI0_I852_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I852_MN16 (XI0_I852_xn2 I0_B_13_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I852_MN15 (I0_pp6_19 XI0_I852_xan XI0_I852_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I852_MN13 (XI0_I852_xn1 XI0_I852_xn I0_pp6_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I852_MN2 (VSS I0_A_19_b3_2 XI0_I852_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I852_MN4 (XI0_I852_n2 I0_A_18_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I852_MN3 (XI0_I852_xn I0_two6_b3_3 XI0_I852_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I852_MN1 (XI0_I852_n1 I0_one6_b3_3 XI0_I852_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I852_MN9 (VSS XI0_I852_xn XI0_I852_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I906_MN11 (VSS I0_B_15_b3_3 XI0_I906_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I906_MN14 (VSS XI0_I906_xbn XI0_I906_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I906_MN16 (XI0_I906_xn2 I0_B_15_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I906_MN15 (I0_pp7_18 XI0_I906_xan XI0_I906_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I906_MN13 (XI0_I906_xn1 XI0_I906_xn I0_pp7_18 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I906_MN2 (VSS I0_A_18_b3_2 XI0_I906_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I906_MN4 (XI0_I906_n2 I0_A_17_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I906_MN3 (XI0_I906_xn I0_two7_b3_3 XI0_I906_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I906_MN1 (XI0_I906_n1 I0_one7_b3_3 XI0_I906_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I906_MN9 (VSS XI0_I906_xn XI0_I906_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I908_MN11 (VSS I0_B_15_b3_3 XI0_I908_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I908_MN14 (VSS XI0_I908_xbn XI0_I908_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I908_MN16 (XI0_I908_xn2 I0_B_15_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I908_MN15 (I0_pp7_20 XI0_I908_xan XI0_I908_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I908_MN13 (XI0_I908_xn1 XI0_I908_xn I0_pp7_20 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I908_MN2 (VSS I0_A_20_b3_2 XI0_I908_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I908_MN4 (XI0_I908_n2 I0_A_19_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I908_MN3 (XI0_I908_xn I0_two7_b3_3 XI0_I908_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I908_MN1 (XI0_I908_n1 I0_one7_b3_3 XI0_I908_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I908_MN9 (VSS XI0_I908_xn XI0_I908_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I909_MN11 (VSS I0_B_15_b3_3 XI0_I909_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I909_MN14 (VSS XI0_I909_xbn XI0_I909_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I909_MN16 (XI0_I909_xn2 I0_B_15_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I909_MN15 (I0_pp7_21 XI0_I909_xan XI0_I909_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I909_MN13 (XI0_I909_xn1 XI0_I909_xn I0_pp7_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I909_MN2 (VSS I0_A_21_b3_2 XI0_I909_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I909_MN4 (XI0_I909_n2 I0_A_20_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I909_MN3 (XI0_I909_xn I0_two7_b3_3 XI0_I909_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I909_MN1 (XI0_I909_n1 I0_one7_b3_3 XI0_I909_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I909_MN9 (VSS XI0_I909_xn XI0_I909_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I855_MN11 (VSS I0_B_13_b3_3 XI0_I855_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I855_MN14 (VSS XI0_I855_xbn XI0_I855_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I855_MN16 (XI0_I855_xn2 I0_B_13_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I855_MN15 (I0_pp6_22 XI0_I855_xan XI0_I855_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I855_MN13 (XI0_I855_xn1 XI0_I855_xn I0_pp6_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I855_MN2 (VSS I0_A_22_b3_2 XI0_I855_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I855_MN4 (XI0_I855_n2 I0_A_21_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I855_MN3 (XI0_I855_xn I0_two6_b3_4 XI0_I855_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I855_MN1 (XI0_I855_n1 I0_one6_b3_4 XI0_I855_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I855_MN9 (VSS XI0_I855_xn XI0_I855_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I907_MN11 (VSS I0_B_15_b3_3 XI0_I907_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I907_MN14 (VSS XI0_I907_xbn XI0_I907_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I907_MN16 (XI0_I907_xn2 I0_B_15_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I907_MN15 (I0_pp7_19 XI0_I907_xan XI0_I907_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I907_MN13 (XI0_I907_xn1 XI0_I907_xn I0_pp7_19 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I907_MN2 (VSS I0_A_19_b3_2 XI0_I907_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I907_MN4 (XI0_I907_n2 I0_A_18_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I907_MN3 (XI0_I907_xn I0_two7_b3_3 XI0_I907_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I907_MN1 (XI0_I907_n1 I0_one7_b3_3 XI0_I907_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I907_MN9 (VSS XI0_I907_xn XI0_I907_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I857_MN11 (VSS I0_B_13_b3_4 XI0_I857_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I857_MN14 (VSS XI0_I857_xbn XI0_I857_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I857_MN16 (XI0_I857_xn2 I0_B_13_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I857_MN15 (I0_pp6_24 XI0_I857_xan XI0_I857_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I857_MN13 (XI0_I857_xn1 XI0_I857_xn I0_pp6_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I857_MN2 (VSS I0_A_24_b3_2 XI0_I857_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I857_MN4 (XI0_I857_n2 I0_A_23_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I857_MN3 (XI0_I857_xn I0_two6_b3_4 XI0_I857_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I857_MN1 (XI0_I857_n1 I0_one6_b3_4 XI0_I857_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I857_MN9 (VSS XI0_I857_xn XI0_I857_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I858_MN11 (VSS I0_B_13_b3_4 XI0_I858_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I858_MN14 (VSS XI0_I858_xbn XI0_I858_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I858_MN16 (XI0_I858_xn2 I0_B_13_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I858_MN15 (I0_pp6_25 XI0_I858_xan XI0_I858_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I858_MN13 (XI0_I858_xn1 XI0_I858_xn I0_pp6_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I858_MN2 (VSS I0_A_25_b3_2 XI0_I858_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I858_MN4 (XI0_I858_n2 I0_A_24_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I858_MN3 (XI0_I858_xn I0_two6_b3_4 XI0_I858_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I858_MN1 (XI0_I858_n1 I0_one6_b3_4 XI0_I858_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I858_MN9 (VSS XI0_I858_xn XI0_I858_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I860_MN11 (VSS I0_B_13_b3_4 XI0_I860_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I860_MN14 (VSS XI0_I860_xbn XI0_I860_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I860_MN16 (XI0_I860_xn2 I0_B_13_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I860_MN15 (I0_pp6_27 XI0_I860_xan XI0_I860_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I860_MN13 (XI0_I860_xn1 XI0_I860_xn I0_pp6_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I860_MN2 (VSS I0_A_27_b3_2 XI0_I860_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I860_MN4 (XI0_I860_n2 I0_A_26_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I860_MN3 (XI0_I860_xn I0_two6_b3_4 XI0_I860_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I860_MN1 (XI0_I860_n1 I0_one6_b3_4 XI0_I860_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I860_MN9 (VSS XI0_I860_xn XI0_I860_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I808_MN11 (VSS I0_B_11_b3_5 XI0_I808_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I808_MN14 (VSS XI0_I808_xbn XI0_I808_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I808_MN16 (XI0_I808_xn2 I0_B_11_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I808_MN15 (I0_pp5_30 XI0_I808_xan XI0_I808_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I808_MN13 (XI0_I808_xn1 XI0_I808_xn I0_pp5_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I808_MN2 (VSS I0_A_30_b3_1 XI0_I808_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I808_MN4 (XI0_I808_n2 I0_A_29_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I808_MN3 (XI0_I808_xn I0_two5_b3_5 XI0_I808_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I808_MN1 (XI0_I808_n1 I0_one5_b3_5 XI0_I808_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I808_MN9 (VSS XI0_I808_xn XI0_I808_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I809_MN11 (VSS I0_B_11_b3_5 XI0_I809_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I809_MN14 (VSS XI0_I809_xbn XI0_I809_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I809_MN16 (XI0_I809_xn2 I0_B_11_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I809_MN15 (I0_pp5_31 XI0_I809_xan XI0_I809_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I809_MN13 (XI0_I809_xn1 XI0_I809_xn I0_pp5_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I809_MN2 (VSS I0_A_31_b3_2 XI0_I809_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I809_MN4 (XI0_I809_n2 I0_A_30_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I809_MN3 (XI0_I809_xn I0_two5_b3_5 XI0_I809_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I809_MN1 (XI0_I809_n1 I0_one5_b3_5 XI0_I809_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I809_MN9 (VSS XI0_I809_xn XI0_I809_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I513_MN11 (VSS I0_B_1_b3_1 XI0_I513_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I513_MN14 (VSS XI0_I513_xbn XI0_I513_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I513_MN16 (XI0_I513_xn2 I0_B_1_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I513_MN15 (I0_pp0_10 XI0_I513_xan XI0_I513_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I513_MN13 (XI0_I513_xn1 XI0_I513_xn I0_pp0_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I513_MN2 (VSS I0_A_10_b3_0 XI0_I513_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I513_MN4 (XI0_I513_n2 I0_A_9_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I513_MN3 (XI0_I513_xn I0_two0_b3_1 XI0_I513_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I513_MN1 (XI0_I513_n1 I0_one0_b3_1 XI0_I513_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I513_MN9 (VSS XI0_I513_xn XI0_I513_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I568_MN11 (VSS I0_B_3_b3_1 XI0_I568_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I568_MN14 (VSS XI0_I568_xbn XI0_I568_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I568_MN16 (XI0_I568_xn2 I0_B_3_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I568_MN15 (I0_pp1_10 XI0_I568_xan XI0_I568_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I568_MN13 (XI0_I568_xn1 XI0_I568_xn I0_pp1_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I568_MN2 (VSS I0_A_10_b3_0 XI0_I568_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I568_MN4 (XI0_I568_n2 I0_A_9_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I568_MN3 (XI0_I568_xn I0_two1_b3_1 XI0_I568_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I568_MN1 (XI0_I568_n1 I0_one1_b3_1 XI0_I568_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I568_MN9 (VSS XI0_I568_xn XI0_I568_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I678_MN11 (VSS I0_B_7_b3_1 XI0_I678_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I678_MN14 (VSS XI0_I678_xbn XI0_I678_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I678_MN16 (XI0_I678_xn2 I0_B_7_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I678_MN15 (I0_pp3_10 XI0_I678_xan XI0_I678_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I678_MN13 (XI0_I678_xn1 XI0_I678_xn I0_pp3_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I678_MN2 (VSS I0_A_10_b3_1 XI0_I678_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I678_MN4 (XI0_I678_n2 I0_A_9_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I678_MN3 (XI0_I678_xn I0_two3_b3_1 XI0_I678_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I678_MN1 (XI0_I678_n1 I0_one3_b3_1 XI0_I678_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I678_MN9 (VSS XI0_I678_xn XI0_I678_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I734_MN11 (VSS I0_B_9_b3_2 XI0_I734_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I734_MN14 (VSS XI0_I734_xbn XI0_I734_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I734_MN16 (XI0_I734_xn2 I0_B_9_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I734_MN15 (I0_pp4_11 XI0_I734_xan XI0_I734_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I734_MN13 (XI0_I734_xn1 XI0_I734_xn I0_pp4_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I734_MN2 (VSS I0_A_11_b3_1 XI0_I734_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I734_MN4 (XI0_I734_n2 I0_A_10_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I734_MN3 (XI0_I734_xn I0_two4_b3_2 XI0_I734_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I734_MN1 (XI0_I734_n1 I0_one4_b3_2 XI0_I734_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I734_MN9 (VSS XI0_I734_xn XI0_I734_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I789_MN11 (VSS I0_B_11_b3_2 XI0_I789_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I789_MN14 (VSS XI0_I789_xbn XI0_I789_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I789_MN16 (XI0_I789_xn2 I0_B_11_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I789_MN15 (I0_pp5_11 XI0_I789_xan XI0_I789_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I789_MN13 (XI0_I789_xn1 XI0_I789_xn I0_pp5_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I789_MN2 (VSS I0_A_11_b3_1 XI0_I789_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I789_MN4 (XI0_I789_n2 I0_A_10_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I789_MN3 (XI0_I789_xn I0_two5_b3_2 XI0_I789_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I789_MN1 (XI0_I789_n1 I0_one5_b3_2 XI0_I789_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I789_MN9 (VSS XI0_I789_xn XI0_I789_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I790_MN11 (VSS I0_B_11_b3_2 XI0_I790_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I790_MN14 (VSS XI0_I790_xbn XI0_I790_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I790_MN16 (XI0_I790_xn2 I0_B_11_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I790_MN15 (I0_pp5_12 XI0_I790_xan XI0_I790_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I790_MN13 (XI0_I790_xn1 XI0_I790_xn I0_pp5_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I790_MN2 (VSS I0_A_12_b3_1 XI0_I790_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I790_MN4 (XI0_I790_n2 I0_A_11_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I790_MN3 (XI0_I790_xn I0_two5_b3_2 XI0_I790_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I790_MN1 (XI0_I790_n1 I0_one5_b3_2 XI0_I790_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I790_MN9 (VSS XI0_I790_xn XI0_I790_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I791_MN11 (VSS I0_B_11_b3_2 XI0_I791_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I791_MN14 (VSS XI0_I791_xbn XI0_I791_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I791_MN16 (XI0_I791_xn2 I0_B_11_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I791_MN15 (I0_pp5_13 XI0_I791_xan XI0_I791_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I791_MN13 (XI0_I791_xn1 XI0_I791_xn I0_pp5_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I791_MN2 (VSS I0_A_13_b3_1 XI0_I791_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I791_MN4 (XI0_I791_n2 I0_A_12_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I791_MN3 (XI0_I791_xn I0_two5_b3_2 XI0_I791_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I791_MN1 (XI0_I791_n1 I0_one5_b3_2 XI0_I791_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I791_MN9 (VSS XI0_I791_xn XI0_I791_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I792_MN11 (VSS I0_B_11_b3_2 XI0_I792_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I792_MN14 (VSS XI0_I792_xbn XI0_I792_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I792_MN16 (XI0_I792_xn2 I0_B_11_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I792_MN15 (I0_pp5_14 XI0_I792_xan XI0_I792_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I792_MN13 (XI0_I792_xn1 XI0_I792_xn I0_pp5_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I792_MN2 (VSS I0_A_14_b3_1 XI0_I792_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I792_MN4 (XI0_I792_n2 I0_A_13_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I792_MN3 (XI0_I792_xn I0_two5_b3_2 XI0_I792_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I792_MN1 (XI0_I792_n1 I0_one5_b3_2 XI0_I792_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I792_MN9 (VSS XI0_I792_xn XI0_I792_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I793_MN11 (VSS I0_B_11_b3_2 XI0_I793_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I793_MN14 (VSS XI0_I793_xbn XI0_I793_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I793_MN16 (XI0_I793_xn2 I0_B_11_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I793_MN15 (I0_pp5_15 XI0_I793_xan XI0_I793_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I793_MN13 (XI0_I793_xn1 XI0_I793_xn I0_pp5_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I793_MN2 (VSS I0_A_15_b3_1 XI0_I793_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I793_MN4 (XI0_I793_n2 I0_A_14_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I793_MN3 (XI0_I793_xn I0_two5_b3_2 XI0_I793_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I793_MN1 (XI0_I793_n1 I0_one5_b3_2 XI0_I793_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I793_MN9 (VSS XI0_I793_xn XI0_I793_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I846_MN11 (VSS I0_B_13_b3_2 XI0_I846_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I846_MN14 (VSS XI0_I846_xbn XI0_I846_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I846_MN16 (XI0_I846_xn2 I0_B_13_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I846_MN15 (I0_pp6_13 XI0_I846_xan XI0_I846_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I846_MN13 (XI0_I846_xn1 XI0_I846_xn I0_pp6_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I846_MN2 (VSS I0_A_13_b3_2 XI0_I846_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I846_MN4 (XI0_I846_n2 I0_A_12_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I846_MN3 (XI0_I846_xn I0_two6_b3_2 XI0_I846_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I846_MN1 (XI0_I846_n1 I0_one6_b3_2 XI0_I846_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I846_MN9 (VSS XI0_I846_xn XI0_I846_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I845_MN11 (VSS I0_B_13_b3_2 XI0_I845_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I845_MN14 (VSS XI0_I845_xbn XI0_I845_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I845_MN16 (XI0_I845_xn2 I0_B_13_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I845_MN15 (I0_pp6_12 XI0_I845_xan XI0_I845_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I845_MN13 (XI0_I845_xn1 XI0_I845_xn I0_pp6_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I845_MN2 (VSS I0_A_12_b3_2 XI0_I845_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I845_MN4 (XI0_I845_n2 I0_A_11_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I845_MN3 (XI0_I845_xn I0_two6_b3_2 XI0_I845_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I845_MN1 (XI0_I845_n1 I0_one6_b3_2 XI0_I845_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I845_MN9 (VSS XI0_I845_xn XI0_I845_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I844_MN11 (VSS I0_B_13_b3_2 XI0_I844_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I844_MN14 (VSS XI0_I844_xbn XI0_I844_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I844_MN16 (XI0_I844_xn2 I0_B_13_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I844_MN15 (I0_pp6_11 XI0_I844_xan XI0_I844_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I844_MN13 (XI0_I844_xn1 XI0_I844_xn I0_pp6_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I844_MN2 (VSS I0_A_11_b3_2 XI0_I844_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I844_MN4 (XI0_I844_n2 I0_A_10_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I844_MN3 (XI0_I844_xn I0_two6_b3_2 XI0_I844_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I844_MN1 (XI0_I844_n1 I0_one6_b3_2 XI0_I844_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I844_MN9 (VSS XI0_I844_xn XI0_I844_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I847_MN11 (VSS I0_B_13_b3_2 XI0_I847_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I847_MN14 (VSS XI0_I847_xbn XI0_I847_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I847_MN16 (XI0_I847_xn2 I0_B_13_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I847_MN15 (I0_pp6_14 XI0_I847_xan XI0_I847_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I847_MN13 (XI0_I847_xn1 XI0_I847_xn I0_pp6_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I847_MN2 (VSS I0_A_14_b3_2 XI0_I847_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I847_MN4 (XI0_I847_n2 I0_A_13_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I847_MN3 (XI0_I847_xn I0_two6_b3_2 XI0_I847_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I847_MN1 (XI0_I847_n1 I0_one6_b3_2 XI0_I847_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I847_MN9 (VSS XI0_I847_xn XI0_I847_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I901_MN11 (VSS I0_B_15_b3_2 XI0_I901_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I901_MN14 (VSS XI0_I901_xbn XI0_I901_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I901_MN16 (XI0_I901_xn2 I0_B_15_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I901_MN15 (I0_pp7_13 XI0_I901_xan XI0_I901_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I901_MN13 (XI0_I901_xn1 XI0_I901_xn I0_pp7_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I901_MN2 (VSS I0_A_13_b3_2 XI0_I901_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I901_MN4 (XI0_I901_n2 I0_A_12_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I901_MN3 (XI0_I901_xn I0_two7_b3_2 XI0_I901_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I901_MN1 (XI0_I901_n1 I0_one7_b3_2 XI0_I901_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I901_MN9 (VSS XI0_I901_xn XI0_I901_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I848_MN11 (VSS I0_B_13_b3_2 XI0_I848_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I848_MN14 (VSS XI0_I848_xbn XI0_I848_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I848_MN16 (XI0_I848_xn2 I0_B_13_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I848_MN15 (I0_pp6_15 XI0_I848_xan XI0_I848_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I848_MN13 (XI0_I848_xn1 XI0_I848_xn I0_pp6_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I848_MN2 (VSS I0_A_15_b3_2 XI0_I848_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I848_MN4 (XI0_I848_n2 I0_A_14_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I848_MN3 (XI0_I848_xn I0_two6_b3_2 XI0_I848_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I848_MN1 (XI0_I848_n1 I0_one6_b3_2 XI0_I848_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I848_MN9 (VSS XI0_I848_xn XI0_I848_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I854_MN11 (VSS I0_B_13_b3_3 XI0_I854_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I854_MN14 (VSS XI0_I854_xbn XI0_I854_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I854_MN16 (XI0_I854_xn2 I0_B_13_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I854_MN15 (I0_pp6_21 XI0_I854_xan XI0_I854_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I854_MN13 (XI0_I854_xn1 XI0_I854_xn I0_pp6_21 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I854_MN2 (VSS I0_A_21_b3_2 XI0_I854_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I854_MN4 (XI0_I854_n2 I0_A_20_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I854_MN3 (XI0_I854_xn I0_two6_b3_3 XI0_I854_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I854_MN1 (XI0_I854_n1 I0_one6_b3_3 XI0_I854_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I854_MN9 (VSS XI0_I854_xn XI0_I854_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I856_MN11 (VSS I0_B_13_b3_4 XI0_I856_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I856_MN14 (VSS XI0_I856_xbn XI0_I856_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I856_MN16 (XI0_I856_xn2 I0_B_13_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I856_MN15 (I0_pp6_23 XI0_I856_xan XI0_I856_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I856_MN13 (XI0_I856_xn1 XI0_I856_xn I0_pp6_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I856_MN2 (VSS I0_A_23_b3_2 XI0_I856_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I856_MN4 (XI0_I856_n2 I0_A_22_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I856_MN3 (XI0_I856_xn I0_two6_b3_4 XI0_I856_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I856_MN1 (XI0_I856_n1 I0_one6_b3_4 XI0_I856_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I856_MN9 (VSS XI0_I856_xn XI0_I856_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I859_MN11 (VSS I0_B_13_b3_4 XI0_I859_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I859_MN14 (VSS XI0_I859_xbn XI0_I859_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I859_MN16 (XI0_I859_xn2 I0_B_13_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I859_MN15 (I0_pp6_26 XI0_I859_xan XI0_I859_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I859_MN13 (XI0_I859_xn1 XI0_I859_xn I0_pp6_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I859_MN2 (VSS I0_A_26_b3_2 XI0_I859_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I859_MN4 (XI0_I859_n2 I0_A_25_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I859_MN3 (XI0_I859_xn I0_two6_b3_4 XI0_I859_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I859_MN1 (XI0_I859_n1 I0_one6_b3_4 XI0_I859_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I859_MN9 (VSS XI0_I859_xn XI0_I859_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I861_MN11 (VSS I0_B_13_b3_4 XI0_I861_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I861_MN14 (VSS XI0_I861_xbn XI0_I861_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I861_MN16 (XI0_I861_xn2 I0_B_13_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I861_MN15 (I0_pp6_28 XI0_I861_xan XI0_I861_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I861_MN13 (XI0_I861_xn1 XI0_I861_xn I0_pp6_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I861_MN2 (VSS I0_A_28_b3_2 XI0_I861_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I861_MN4 (XI0_I861_n2 I0_A_27_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I861_MN3 (XI0_I861_xn I0_two6_b3_5 XI0_I861_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I861_MN1 (XI0_I861_n1 I0_one6_b3_5 XI0_I861_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I861_MN9 (VSS XI0_I861_xn XI0_I861_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I862_MN11 (VSS I0_B_13_b3_5 XI0_I862_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I862_MN14 (VSS XI0_I862_xbn XI0_I862_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I862_MN16 (XI0_I862_xn2 I0_B_13_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I862_MN15 (I0_pp6_29 XI0_I862_xan XI0_I862_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I862_MN13 (XI0_I862_xn1 XI0_I862_xn I0_pp6_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I862_MN2 (VSS I0_A_29_b3_2 XI0_I862_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I862_MN4 (XI0_I862_n2 I0_A_28_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I862_MN3 (XI0_I862_xn I0_two6_b3_5 XI0_I862_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I862_MN1 (XI0_I862_n1 I0_one6_b3_5 XI0_I862_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I862_MN9 (VSS XI0_I862_xn XI0_I862_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I510_MN11 (VSS I0_B_1_b3_1 XI0_I510_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I510_MN14 (VSS XI0_I510_xbn XI0_I510_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I510_MN16 (XI0_I510_xn2 I0_B_1_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I510_MN15 (I0_pp0_7 XI0_I510_xan XI0_I510_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I510_MN13 (XI0_I510_xn1 XI0_I510_xn I0_pp0_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I510_MN2 (VSS I0_A_7_b3_0 XI0_I510_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I510_MN4 (XI0_I510_n2 I0_A_6_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I510_MN3 (XI0_I510_xn I0_two0_b3_1 XI0_I510_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I510_MN1 (XI0_I510_n1 I0_one0_b3_1 XI0_I510_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I510_MN9 (VSS XI0_I510_xn XI0_I510_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I565_MN11 (VSS I0_B_3_b3_1 XI0_I565_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I565_MN14 (VSS XI0_I565_xbn XI0_I565_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I565_MN16 (XI0_I565_xn2 I0_B_3_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I565_MN15 (I0_pp1_7 XI0_I565_xan XI0_I565_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I565_MN13 (XI0_I565_xn1 XI0_I565_xn I0_pp1_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I565_MN2 (VSS I0_A_7_b3_0 XI0_I565_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I565_MN4 (XI0_I565_n2 I0_A_6_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I565_MN3 (XI0_I565_xn I0_two1_b3_1 XI0_I565_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I565_MN1 (XI0_I565_n1 I0_one1_b3_1 XI0_I565_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I565_MN9 (VSS XI0_I565_xn XI0_I565_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I512_MN11 (VSS I0_B_1_b3_1 XI0_I512_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I512_MN14 (VSS XI0_I512_xbn XI0_I512_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I512_MN16 (XI0_I512_xn2 I0_B_1_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I512_MN15 (I0_pp0_9 XI0_I512_xan XI0_I512_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I512_MN13 (XI0_I512_xn1 XI0_I512_xn I0_pp0_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I512_MN2 (VSS I0_A_9_b3_0 XI0_I512_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I512_MN4 (XI0_I512_n2 I0_A_8_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I512_MN3 (XI0_I512_xn I0_two0_b3_1 XI0_I512_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I512_MN1 (XI0_I512_n1 I0_one0_b3_1 XI0_I512_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I512_MN9 (VSS XI0_I512_xn XI0_I512_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I567_MN11 (VSS I0_B_3_b3_1 XI0_I567_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I567_MN14 (VSS XI0_I567_xbn XI0_I567_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I567_MN16 (XI0_I567_xn2 I0_B_3_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I567_MN15 (I0_pp1_9 XI0_I567_xan XI0_I567_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I567_MN13 (XI0_I567_xn1 XI0_I567_xn I0_pp1_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I567_MN2 (VSS I0_A_9_b3_0 XI0_I567_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I567_MN4 (XI0_I567_n2 I0_A_8_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I567_MN3 (XI0_I567_xn I0_two1_b3_1 XI0_I567_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I567_MN1 (XI0_I567_n1 I0_one1_b3_1 XI0_I567_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I567_MN9 (VSS XI0_I567_xn XI0_I567_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I622_MN11 (VSS I0_B_5_b3_1 XI0_I622_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I622_MN14 (VSS XI0_I622_xbn XI0_I622_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I622_MN16 (XI0_I622_xn2 I0_B_5_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I622_MN15 (I0_pp2_9 XI0_I622_xan XI0_I622_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I622_MN13 (XI0_I622_xn1 XI0_I622_xn I0_pp2_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I622_MN2 (VSS I0_A_9_b3_0 XI0_I622_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I622_MN4 (XI0_I622_n2 I0_A_8_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I622_MN3 (XI0_I622_xn I0_two2_b3_1 XI0_I622_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I622_MN1 (XI0_I622_n1 I0_one2_b3_1 XI0_I622_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I622_MN9 (VSS XI0_I622_xn XI0_I622_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I675_MN11 (VSS I0_B_7_b3_1 XI0_I675_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I675_MN14 (VSS XI0_I675_xbn XI0_I675_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I675_MN16 (XI0_I675_xn2 I0_B_7_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I675_MN15 (I0_pp3_7 XI0_I675_xan XI0_I675_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I675_MN13 (XI0_I675_xn1 XI0_I675_xn I0_pp3_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I675_MN2 (VSS I0_A_7_b3_1 XI0_I675_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I675_MN4 (XI0_I675_n2 I0_A_6_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I675_MN3 (XI0_I675_xn I0_two3_b3_1 XI0_I675_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I675_MN1 (XI0_I675_n1 I0_one3_b3_1 XI0_I675_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I675_MN9 (VSS XI0_I675_xn XI0_I675_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I676_MN11 (VSS I0_B_7_b3_1 XI0_I676_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I676_MN14 (VSS XI0_I676_xbn XI0_I676_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I676_MN16 (XI0_I676_xn2 I0_B_7_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I676_MN15 (I0_pp3_8 XI0_I676_xan XI0_I676_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I676_MN13 (XI0_I676_xn1 XI0_I676_xn I0_pp3_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I676_MN2 (VSS I0_A_8_b3_1 XI0_I676_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I676_MN4 (XI0_I676_n2 I0_A_7_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I676_MN3 (XI0_I676_xn I0_two3_b3_1 XI0_I676_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I676_MN1 (XI0_I676_n1 I0_one3_b3_1 XI0_I676_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I676_MN9 (VSS XI0_I676_xn XI0_I676_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I677_MN11 (VSS I0_B_7_b3_1 XI0_I677_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I677_MN14 (VSS XI0_I677_xbn XI0_I677_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I677_MN16 (XI0_I677_xn2 I0_B_7_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I677_MN15 (I0_pp3_9 XI0_I677_xan XI0_I677_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I677_MN13 (XI0_I677_xn1 XI0_I677_xn I0_pp3_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I677_MN2 (VSS I0_A_9_b3_1 XI0_I677_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I677_MN4 (XI0_I677_n2 I0_A_8_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I677_MN3 (XI0_I677_xn I0_two3_b3_1 XI0_I677_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I677_MN1 (XI0_I677_n1 I0_one3_b3_1 XI0_I677_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I677_MN9 (VSS XI0_I677_xn XI0_I677_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I843_MN11 (VSS I0_B_13_b3_1 XI0_I843_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I843_MN14 (VSS XI0_I843_xbn XI0_I843_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I843_MN16 (XI0_I843_xn2 I0_B_13_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I843_MN15 (I0_pp6_10 XI0_I843_xan XI0_I843_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I843_MN13 (XI0_I843_xn1 XI0_I843_xn I0_pp6_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I843_MN2 (VSS I0_A_10_b3_2 XI0_I843_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I843_MN4 (XI0_I843_n2 I0_A_9_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I843_MN3 (XI0_I843_xn I0_two6_b3_1 XI0_I843_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I843_MN1 (XI0_I843_n1 I0_one6_b3_1 XI0_I843_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I843_MN9 (VSS XI0_I843_xn XI0_I843_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I736_MN11 (VSS I0_B_9_b3_2 XI0_I736_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I736_MN14 (VSS XI0_I736_xbn XI0_I736_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I736_MN16 (XI0_I736_xn2 I0_B_9_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I736_MN15 (I0_pp4_13 XI0_I736_xan XI0_I736_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I736_MN13 (XI0_I736_xn1 XI0_I736_xn I0_pp4_13 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I736_MN2 (VSS I0_A_13_b3_1 XI0_I736_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I736_MN4 (XI0_I736_n2 I0_A_12_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I736_MN3 (XI0_I736_xn I0_two4_b3_2 XI0_I736_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I736_MN1 (XI0_I736_n1 I0_one4_b3_2 XI0_I736_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I736_MN9 (VSS XI0_I736_xn XI0_I736_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I735_MN11 (VSS I0_B_9_b3_2 XI0_I735_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I735_MN14 (VSS XI0_I735_xbn XI0_I735_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I735_MN16 (XI0_I735_xn2 I0_B_9_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I735_MN15 (I0_pp4_12 XI0_I735_xan XI0_I735_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I735_MN13 (XI0_I735_xn1 XI0_I735_xn I0_pp4_12 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I735_MN2 (VSS I0_A_12_b3_1 XI0_I735_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I735_MN4 (XI0_I735_n2 I0_A_11_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I735_MN3 (XI0_I735_xn I0_two4_b3_2 XI0_I735_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I735_MN1 (XI0_I735_n1 I0_one4_b3_2 XI0_I735_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I735_MN9 (VSS XI0_I735_xn XI0_I735_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I737_MN11 (VSS I0_B_9_b3_2 XI0_I737_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I737_MN14 (VSS XI0_I737_xbn XI0_I737_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I737_MN16 (XI0_I737_xn2 I0_B_9_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I737_MN15 (I0_pp4_14 XI0_I737_xan XI0_I737_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I737_MN13 (XI0_I737_xn1 XI0_I737_xn I0_pp4_14 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I737_MN2 (VSS I0_A_14_b3_1 XI0_I737_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I737_MN4 (XI0_I737_n2 I0_A_13_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I737_MN3 (XI0_I737_xn I0_two4_b3_2 XI0_I737_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I737_MN1 (XI0_I737_n1 I0_one4_b3_2 XI0_I737_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I737_MN9 (VSS XI0_I737_xn XI0_I737_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I738_MN11 (VSS I0_B_9_b3_2 XI0_I738_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I738_MN14 (VSS XI0_I738_xbn XI0_I738_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I738_MN16 (XI0_I738_xn2 I0_B_9_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I738_MN15 (I0_pp4_15 XI0_I738_xan XI0_I738_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I738_MN13 (XI0_I738_xn1 XI0_I738_xn I0_pp4_15 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I738_MN2 (VSS I0_A_15_b3_1 XI0_I738_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I738_MN4 (XI0_I738_n2 I0_A_14_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I738_MN3 (XI0_I738_xn I0_two4_b3_2 XI0_I738_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I738_MN1 (XI0_I738_n1 I0_one4_b3_2 XI0_I738_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I738_MN9 (VSS XI0_I738_xn XI0_I738_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I739_MN11 (VSS I0_B_9_b3_2 XI0_I739_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I739_MN14 (VSS XI0_I739_xbn XI0_I739_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I739_MN16 (XI0_I739_xn2 I0_B_9_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I739_MN15 (I0_pp4_16 XI0_I739_xan XI0_I739_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I739_MN13 (XI0_I739_xn1 XI0_I739_xn I0_pp4_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I739_MN2 (VSS I0_A_16_b3_1 XI0_I739_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I739_MN4 (XI0_I739_n2 I0_A_15_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I739_MN3 (XI0_I739_xn I0_two4_b3_2 XI0_I739_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I739_MN1 (XI0_I739_n1 I0_one4_b3_2 XI0_I739_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I739_MN9 (VSS XI0_I739_xn XI0_I739_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I899_MN11 (VSS I0_B_15_b3_2 XI0_I899_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I899_MN14 (VSS XI0_I899_xbn XI0_I899_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I899_MN16 (XI0_I899_xn2 I0_B_15_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I899_MN15 (I0_pp7_11 XI0_I899_xan XI0_I899_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I899_MN13 (XI0_I899_xn1 XI0_I899_xn I0_pp7_11 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I899_MN2 (VSS I0_A_11_b3_2 XI0_I899_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I899_MN4 (XI0_I899_n2 I0_A_10_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I899_MN3 (XI0_I899_xn I0_two7_b3_2 XI0_I899_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I899_MN1 (XI0_I899_n1 I0_one7_b3_2 XI0_I899_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I899_MN9 (VSS XI0_I899_xn XI0_I899_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I849_MN11 (VSS I0_B_13_b3_2 XI0_I849_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I849_MN14 (VSS XI0_I849_xbn XI0_I849_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I849_MN16 (XI0_I849_xn2 I0_B_13_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I849_MN15 (I0_pp6_16 XI0_I849_xan XI0_I849_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I849_MN13 (XI0_I849_xn1 XI0_I849_xn I0_pp6_16 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I849_MN2 (VSS I0_A_16_b3_2 XI0_I849_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I849_MN4 (XI0_I849_n2 I0_A_15_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I849_MN3 (XI0_I849_xn I0_two6_b3_2 XI0_I849_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I849_MN1 (XI0_I849_n1 I0_one6_b3_2 XI0_I849_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I849_MN9 (VSS XI0_I849_xn XI0_I849_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I910_MN11 (VSS I0_B_15_b3_3 XI0_I910_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I910_MN14 (VSS XI0_I910_xbn XI0_I910_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I910_MN16 (XI0_I910_xn2 I0_B_15_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I910_MN15 (I0_pp7_22 XI0_I910_xan XI0_I910_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I910_MN13 (XI0_I910_xn1 XI0_I910_xn I0_pp7_22 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I910_MN2 (VSS I0_A_22_b3_2 XI0_I910_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I910_MN4 (XI0_I910_n2 I0_A_21_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I910_MN3 (XI0_I910_xn I0_two7_b3_4 XI0_I910_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I910_MN1 (XI0_I910_n1 I0_one7_b3_4 XI0_I910_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I910_MN9 (VSS XI0_I910_xn XI0_I910_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I911_MN11 (VSS I0_B_15_b3_4 XI0_I911_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I911_MN14 (VSS XI0_I911_xbn XI0_I911_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I911_MN16 (XI0_I911_xn2 I0_B_15_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I911_MN15 (I0_pp7_23 XI0_I911_xan XI0_I911_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I911_MN13 (XI0_I911_xn1 XI0_I911_xn I0_pp7_23 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I911_MN2 (VSS I0_A_23_b3_2 XI0_I911_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I911_MN4 (XI0_I911_n2 I0_A_22_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I911_MN3 (XI0_I911_xn I0_two7_b3_4 XI0_I911_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I911_MN1 (XI0_I911_n1 I0_one7_b3_4 XI0_I911_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I911_MN9 (VSS XI0_I911_xn XI0_I911_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I913_MN11 (VSS I0_B_15_b3_4 XI0_I913_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I913_MN14 (VSS XI0_I913_xbn XI0_I913_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I913_MN16 (XI0_I913_xn2 I0_B_15_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I913_MN15 (I0_pp7_25 XI0_I913_xan XI0_I913_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I913_MN13 (XI0_I913_xn1 XI0_I913_xn I0_pp7_25 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I913_MN2 (VSS I0_A_25_b3_2 XI0_I913_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I913_MN4 (XI0_I913_n2 I0_A_24_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I913_MN3 (XI0_I913_xn I0_two7_b3_4 XI0_I913_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I913_MN1 (XI0_I913_n1 I0_one7_b3_4 XI0_I913_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I913_MN9 (VSS XI0_I913_xn XI0_I913_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I912_MN11 (VSS I0_B_15_b3_4 XI0_I912_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I912_MN14 (VSS XI0_I912_xbn XI0_I912_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I912_MN16 (XI0_I912_xn2 I0_B_15_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I912_MN15 (I0_pp7_24 XI0_I912_xan XI0_I912_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I912_MN13 (XI0_I912_xn1 XI0_I912_xn I0_pp7_24 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I912_MN2 (VSS I0_A_24_b3_2 XI0_I912_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I912_MN4 (XI0_I912_n2 I0_A_23_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I912_MN3 (XI0_I912_xn I0_two7_b3_4 XI0_I912_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I912_MN1 (XI0_I912_n1 I0_one7_b3_4 XI0_I912_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I912_MN9 (VSS XI0_I912_xn XI0_I912_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I915_MN11 (VSS I0_B_15_b3_4 XI0_I915_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I915_MN14 (VSS XI0_I915_xbn XI0_I915_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I915_MN16 (XI0_I915_xn2 I0_B_15_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I915_MN15 (I0_pp7_27 XI0_I915_xan XI0_I915_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I915_MN13 (XI0_I915_xn1 XI0_I915_xn I0_pp7_27 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I915_MN2 (VSS I0_A_27_b3_2 XI0_I915_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I915_MN4 (XI0_I915_n2 I0_A_26_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I915_MN3 (XI0_I915_xn I0_two7_b3_4 XI0_I915_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I915_MN1 (XI0_I915_n1 I0_one7_b3_4 XI0_I915_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I915_MN9 (VSS XI0_I915_xn XI0_I915_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I863_MN11 (VSS I0_B_13_b3_5 XI0_I863_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I863_MN14 (VSS XI0_I863_xbn XI0_I863_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I863_MN16 (XI0_I863_xn2 I0_B_13_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I863_MN15 (I0_pp6_30 XI0_I863_xan XI0_I863_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I863_MN13 (XI0_I863_xn1 XI0_I863_xn I0_pp6_30 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I863_MN2 (VSS I0_A_30_b3_2 XI0_I863_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I863_MN4 (XI0_I863_n2 I0_A_29_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I863_MN3 (XI0_I863_xn I0_two6_b3_5 XI0_I863_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I863_MN1 (XI0_I863_n1 I0_one6_b3_5 XI0_I863_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I863_MN9 (VSS XI0_I863_xn XI0_I863_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I865_MN11 (VSS I0_B_13_b3_5 XI0_I865_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I865_MN14 (VSS XI0_I865_xbn XI0_I865_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I865_MN16 (XI0_I865_xn2 I0_B_13_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I865_MN15 (I0_pp6_32 XI0_I865_xan XI0_I865_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I865_MN13 (XI0_I865_xn1 XI0_I865_xn I0_pp6_32 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I865_MN2 (VSS I0_A_31_b3_3 XI0_I865_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I865_MN4 (XI0_I865_n2 I0_A_31_b3_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I865_MN3 (XI0_I865_xn I0_two6_b3_5 XI0_I865_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I865_MN1 (XI0_I865_n1 I0_one6_b3_5 XI0_I865_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I865_MN9 (VSS XI0_I865_xn XI0_I865_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I511_MN11 (VSS I0_B_1_b3_1 XI0_I511_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I511_MN14 (VSS XI0_I511_xbn XI0_I511_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I511_MN16 (XI0_I511_xn2 I0_B_1_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I511_MN15 (I0_pp0_8 XI0_I511_xan XI0_I511_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I511_MN13 (XI0_I511_xn1 XI0_I511_xn I0_pp0_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I511_MN2 (VSS I0_A_8_b3_0 XI0_I511_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I511_MN4 (XI0_I511_n2 I0_A_7_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I511_MN3 (XI0_I511_xn I0_two0_b3_1 XI0_I511_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I511_MN1 (XI0_I511_n1 I0_one0_b3_1 XI0_I511_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I511_MN9 (VSS XI0_I511_xn XI0_I511_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I509_MN11 (VSS I0_B_1_b3_1 XI0_I509_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I509_MN14 (VSS XI0_I509_xbn XI0_I509_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I509_MN16 (XI0_I509_xn2 I0_B_1_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I509_MN15 (I0_pp0_6 XI0_I509_xan XI0_I509_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I509_MN13 (XI0_I509_xn1 XI0_I509_xn I0_pp0_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I509_MN2 (VSS I0_A_6_b3_0 XI0_I509_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I509_MN4 (XI0_I509_n2 I0_A_5_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I509_MN3 (XI0_I509_xn I0_two0_b3_1 XI0_I509_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I509_MN1 (XI0_I509_n1 I0_one0_b3_1 XI0_I509_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I509_MN9 (VSS XI0_I509_xn XI0_I509_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I564_MN11 (VSS I0_B_3_b3_1 XI0_I564_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I564_MN14 (VSS XI0_I564_xbn XI0_I564_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I564_MN16 (XI0_I564_xn2 I0_B_3_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I564_MN15 (I0_pp1_6 XI0_I564_xan XI0_I564_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I564_MN13 (XI0_I564_xn1 XI0_I564_xn I0_pp1_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I564_MN2 (VSS I0_A_6_b3_0 XI0_I564_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I564_MN4 (XI0_I564_n2 I0_A_5_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I564_MN3 (XI0_I564_xn I0_two1_b3_1 XI0_I564_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I564_MN1 (XI0_I564_n1 I0_one1_b3_1 XI0_I564_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I564_MN9 (VSS XI0_I564_xn XI0_I564_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I618_MN11 (VSS I0_B_5_b3_1 XI0_I618_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I618_MN14 (VSS XI0_I618_xbn XI0_I618_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I618_MN16 (XI0_I618_xn2 I0_B_5_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I618_MN15 (I0_pp2_5 XI0_I618_xan XI0_I618_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I618_MN13 (XI0_I618_xn1 XI0_I618_xn I0_pp2_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I618_MN2 (VSS I0_A_5_b3_0 XI0_I618_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I618_MN4 (XI0_I618_n2 I0_A_4_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I618_MN3 (XI0_I618_xn I0_two2_b3_0 XI0_I618_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I618_MN1 (XI0_I618_n1 I0_one2_b3_0 XI0_I618_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I618_MN9 (VSS XI0_I618_xn XI0_I618_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I619_MN11 (VSS I0_B_5_b3_1 XI0_I619_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I619_MN14 (VSS XI0_I619_xbn XI0_I619_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I619_MN16 (XI0_I619_xn2 I0_B_5_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I619_MN15 (I0_pp2_6 XI0_I619_xan XI0_I619_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I619_MN13 (XI0_I619_xn1 XI0_I619_xn I0_pp2_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I619_MN2 (VSS I0_A_6_b3_0 XI0_I619_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I619_MN4 (XI0_I619_n2 I0_A_5_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I619_MN3 (XI0_I619_xn I0_two2_b3_1 XI0_I619_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I619_MN1 (XI0_I619_n1 I0_one2_b3_1 XI0_I619_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I619_MN9 (VSS XI0_I619_xn XI0_I619_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I566_MN11 (VSS I0_B_3_b3_1 XI0_I566_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I566_MN14 (VSS XI0_I566_xbn XI0_I566_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I566_MN16 (XI0_I566_xn2 I0_B_3_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I566_MN15 (I0_pp1_8 XI0_I566_xan XI0_I566_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I566_MN13 (XI0_I566_xn1 XI0_I566_xn I0_pp1_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I566_MN2 (VSS I0_A_8_b3_0 XI0_I566_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I566_MN4 (XI0_I566_n2 I0_A_7_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I566_MN3 (XI0_I566_xn I0_two1_b3_1 XI0_I566_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I566_MN1 (XI0_I566_n1 I0_one1_b3_1 XI0_I566_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I566_MN9 (VSS XI0_I566_xn XI0_I566_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I621_MN11 (VSS I0_B_5_b3_1 XI0_I621_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I621_MN14 (VSS XI0_I621_xbn XI0_I621_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I621_MN16 (XI0_I621_xn2 I0_B_5_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I621_MN15 (I0_pp2_8 XI0_I621_xan XI0_I621_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I621_MN13 (XI0_I621_xn1 XI0_I621_xn I0_pp2_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I621_MN2 (VSS I0_A_8_b3_0 XI0_I621_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I621_MN4 (XI0_I621_n2 I0_A_7_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I621_MN3 (XI0_I621_xn I0_two2_b3_1 XI0_I621_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I621_MN1 (XI0_I621_n1 I0_one2_b3_1 XI0_I621_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I621_MN9 (VSS XI0_I621_xn XI0_I621_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I620_MN11 (VSS I0_B_5_b3_1 XI0_I620_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I620_MN14 (VSS XI0_I620_xbn XI0_I620_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I620_MN16 (XI0_I620_xn2 I0_B_5_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I620_MN15 (I0_pp2_7 XI0_I620_xan XI0_I620_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I620_MN13 (XI0_I620_xn1 XI0_I620_xn I0_pp2_7 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I620_MN2 (VSS I0_A_7_b3_0 XI0_I620_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I620_MN4 (XI0_I620_n2 I0_A_6_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I620_MN3 (XI0_I620_xn I0_two2_b3_1 XI0_I620_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I620_MN1 (XI0_I620_n1 I0_one2_b3_1 XI0_I620_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I620_MN9 (VSS XI0_I620_xn XI0_I620_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I674_MN11 (VSS I0_B_7_b3_1 XI0_I674_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I674_MN14 (VSS XI0_I674_xbn XI0_I674_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I674_MN16 (XI0_I674_xn2 I0_B_7_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I674_MN15 (I0_pp3_6 XI0_I674_xan XI0_I674_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I674_MN13 (XI0_I674_xn1 XI0_I674_xn I0_pp3_6 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I674_MN2 (VSS I0_A_6_b3_1 XI0_I674_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I674_MN4 (XI0_I674_n2 I0_A_5_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I674_MN3 (XI0_I674_xn I0_two3_b3_1 XI0_I674_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I674_MN1 (XI0_I674_n1 I0_one3_b3_1 XI0_I674_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I674_MN9 (VSS XI0_I674_xn XI0_I674_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I673_MN11 (VSS I0_B_7_b3_1 XI0_I673_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I673_MN14 (VSS XI0_I673_xbn XI0_I673_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I673_MN16 (XI0_I673_xn2 I0_B_7_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I673_MN15 (I0_pp3_5 XI0_I673_xan XI0_I673_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I673_MN13 (XI0_I673_xn1 XI0_I673_xn I0_pp3_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I673_MN2 (VSS I0_A_5_b3_1 XI0_I673_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I673_MN4 (XI0_I673_n2 I0_A_4_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I673_MN3 (XI0_I673_xn I0_two3_b3_0 XI0_I673_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I673_MN1 (XI0_I673_n1 I0_one3_b3_0 XI0_I673_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I673_MN9 (VSS XI0_I673_xn XI0_I673_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I733_MN11 (VSS I0_B_9_b3_1 XI0_I733_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I733_MN14 (VSS XI0_I733_xbn XI0_I733_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I733_MN16 (XI0_I733_xn2 I0_B_9_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I733_MN15 (I0_pp4_10 XI0_I733_xan XI0_I733_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I733_MN13 (XI0_I733_xn1 XI0_I733_xn I0_pp4_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I733_MN2 (VSS I0_A_10_b3_1 XI0_I733_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I733_MN4 (XI0_I733_n2 I0_A_9_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I733_MN3 (XI0_I733_xn I0_two4_b3_1 XI0_I733_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I733_MN1 (XI0_I733_n1 I0_one4_b3_1 XI0_I733_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I733_MN9 (VSS XI0_I733_xn XI0_I733_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I788_MN11 (VSS I0_B_11_b3_1 XI0_I788_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I788_MN14 (VSS XI0_I788_xbn XI0_I788_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I788_MN16 (XI0_I788_xn2 I0_B_11_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I788_MN15 (I0_pp5_10 XI0_I788_xan XI0_I788_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I788_MN13 (XI0_I788_xn1 XI0_I788_xn I0_pp5_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I788_MN2 (VSS I0_A_10_b3_1 XI0_I788_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I788_MN4 (XI0_I788_n2 I0_A_9_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I788_MN3 (XI0_I788_xn I0_two5_b3_1 XI0_I788_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I788_MN1 (XI0_I788_n1 I0_one5_b3_1 XI0_I788_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I788_MN9 (VSS XI0_I788_xn XI0_I788_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I842_MN11 (VSS I0_B_13_b3_1 XI0_I842_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I842_MN14 (VSS XI0_I842_xbn XI0_I842_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I842_MN16 (XI0_I842_xn2 I0_B_13_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I842_MN15 (I0_pp6_9 XI0_I842_xan XI0_I842_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I842_MN13 (XI0_I842_xn1 XI0_I842_xn I0_pp6_9 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I842_MN2 (VSS I0_A_9_b3_2 XI0_I842_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I842_MN4 (XI0_I842_n2 I0_A_8_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I842_MN3 (XI0_I842_xn I0_two6_b3_1 XI0_I842_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I842_MN1 (XI0_I842_n1 I0_one6_b3_1 XI0_I842_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I842_MN9 (VSS XI0_I842_xn XI0_I842_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I896_MN11 (VSS I0_B_15_b3_1 XI0_I896_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I896_MN14 (VSS XI0_I896_xbn XI0_I896_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I896_MN16 (XI0_I896_xn2 I0_B_15_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I896_MN15 (I0_pp7_8 XI0_I896_xan XI0_I896_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I896_MN13 (XI0_I896_xn1 XI0_I896_xn I0_pp7_8 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I896_MN2 (VSS I0_A_8_b3_2 XI0_I896_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I896_MN4 (XI0_I896_n2 I0_A_7_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I896_MN3 (XI0_I896_xn I0_two7_b3_1 XI0_I896_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I896_MN1 (XI0_I896_n1 I0_one7_b3_1 XI0_I896_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I896_MN9 (VSS XI0_I896_xn XI0_I896_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I898_MN11 (VSS I0_B_15_b3_1 XI0_I898_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I898_MN14 (VSS XI0_I898_xbn XI0_I898_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I898_MN16 (XI0_I898_xn2 I0_B_15_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I898_MN15 (I0_pp7_10 XI0_I898_xan XI0_I898_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I898_MN13 (XI0_I898_xn1 XI0_I898_xn I0_pp7_10 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I898_MN2 (VSS I0_A_10_b3_2 XI0_I898_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I898_MN4 (XI0_I898_n2 I0_A_9_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I898_MN3 (XI0_I898_xn I0_two7_b3_1 XI0_I898_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I898_MN1 (XI0_I898_n1 I0_one7_b3_1 XI0_I898_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I898_MN9 (VSS XI0_I898_xn XI0_I898_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I914_MN11 (VSS I0_B_15_b3_4 XI0_I914_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I914_MN14 (VSS XI0_I914_xbn XI0_I914_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I914_MN16 (XI0_I914_xn2 I0_B_15_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I914_MN15 (I0_pp7_26 XI0_I914_xan XI0_I914_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I914_MN13 (XI0_I914_xn1 XI0_I914_xn I0_pp7_26 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I914_MN2 (VSS I0_A_26_b3_2 XI0_I914_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I914_MN4 (XI0_I914_n2 I0_A_25_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I914_MN3 (XI0_I914_xn I0_two7_b3_4 XI0_I914_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I914_MN1 (XI0_I914_n1 I0_one7_b3_4 XI0_I914_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I914_MN9 (VSS XI0_I914_xn XI0_I914_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I916_MN11 (VSS I0_B_15_b3_4 XI0_I916_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I916_MN14 (VSS XI0_I916_xbn XI0_I916_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I916_MN16 (XI0_I916_xn2 I0_B_15_b3_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I916_MN15 (I0_pp7_28 XI0_I916_xan XI0_I916_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I916_MN13 (XI0_I916_xn1 XI0_I916_xn I0_pp7_28 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I916_MN2 (VSS I0_A_28_b3_2 XI0_I916_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I916_MN4 (XI0_I916_n2 I0_A_27_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I916_MN3 (XI0_I916_xn I0_two7_b3_5 XI0_I916_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I916_MN1 (XI0_I916_n1 I0_one7_b3_5 XI0_I916_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I916_MN9 (VSS XI0_I916_xn XI0_I916_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I917_MN11 (VSS I0_B_15_b3_5 XI0_I917_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I917_MN14 (VSS XI0_I917_xbn XI0_I917_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I917_MN16 (XI0_I917_xn2 I0_B_15_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I917_MN15 (I0_pp7_29 XI0_I917_xan XI0_I917_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I917_MN13 (XI0_I917_xn1 XI0_I917_xn I0_pp7_29 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I917_MN2 (VSS I0_A_29_b3_2 XI0_I917_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I917_MN4 (XI0_I917_n2 I0_A_28_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I917_MN3 (XI0_I917_xn I0_two7_b3_5 XI0_I917_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I917_MN1 (XI0_I917_n1 I0_one7_b3_5 XI0_I917_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I917_MN9 (VSS XI0_I917_xn XI0_I917_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I919_MN11 (VSS I0_B_15_b3_5 XI0_I919_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I919_MN14 (VSS XI0_I919_xbn XI0_I919_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I919_MN16 (XI0_I919_xn2 I0_B_15_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I919_MN15 (I0_pp7_31 XI0_I919_xan XI0_I919_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I919_MN13 (XI0_I919_xn1 XI0_I919_xn I0_pp7_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I919_MN2 (VSS I0_A_31_b3_3 XI0_I919_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I919_MN4 (XI0_I919_n2 I0_A_30_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I919_MN3 (XI0_I919_xn I0_two7_b3_5 XI0_I919_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I919_MN1 (XI0_I919_n1 I0_one7_b3_5 XI0_I919_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I919_MN9 (VSS XI0_I919_xn XI0_I919_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I864_MN11 (VSS I0_B_13_b3_5 XI0_I864_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I864_MN14 (VSS XI0_I864_xbn XI0_I864_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I864_MN16 (XI0_I864_xn2 I0_B_13_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I864_MN15 (I0_pp6_31 XI0_I864_xan XI0_I864_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I864_MN13 (XI0_I864_xn1 XI0_I864_xn I0_pp6_31 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I864_MN2 (VSS I0_A_31_b3_3 XI0_I864_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I864_MN4 (XI0_I864_n2 I0_A_30_b3_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I864_MN3 (XI0_I864_xn I0_two6_b3_5 XI0_I864_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I864_MN1 (XI0_I864_n1 I0_one6_b3_5 XI0_I864_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I864_MN9 (VSS XI0_I864_xn XI0_I864_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I508_MN11 (VSS I0_B_1_b3_1 XI0_I508_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I508_MN14 (VSS XI0_I508_xbn XI0_I508_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I508_MN16 (XI0_I508_xn2 I0_B_1_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I508_MN15 (I0_pp0_5 XI0_I508_xan XI0_I508_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I508_MN13 (XI0_I508_xn1 XI0_I508_xn I0_pp0_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I508_MN2 (VSS I0_A_5_b3_0 XI0_I508_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I508_MN4 (XI0_I508_n2 I0_A_4_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I508_MN3 (XI0_I508_xn I0_two0_b3_0 XI0_I508_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I508_MN1 (XI0_I508_n1 I0_one0_b3_0 XI0_I508_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I508_MN9 (VSS XI0_I508_xn XI0_I508_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I563_MN11 (VSS I0_B_3_b3_1 XI0_I563_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I563_MN14 (VSS XI0_I563_xbn XI0_I563_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I563_MN16 (XI0_I563_xn2 I0_B_3_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I563_MN15 (I0_pp1_5 XI0_I563_xan XI0_I563_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I563_MN13 (XI0_I563_xn1 XI0_I563_xn I0_pp1_5 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I563_MN2 (VSS I0_A_5_b3_0 XI0_I563_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I563_MN4 (XI0_I563_n2 I0_A_4_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I563_MN3 (XI0_I563_xn I0_two1_b3_0 XI0_I563_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I563_MN1 (XI0_I563_n1 I0_one1_b3_0 XI0_I563_xn VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I563_MN9 (VSS XI0_I563_xn XI0_I563_xan VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I671_MN11 (VSS I0_B_7_b3_0 XI0_I671_xbn VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15999u ps=1.15999u
    I_MXI0_I671_MN14 (VSS XI0_I671_xbn XI0_I671_xn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I671_MN16 (XI0_I671_xn2 I0_B_7_b3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I671_MN15 (I0_pp3_3 XI0_I671_xan XI0_I671_xn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I671_MN13 (XI0_I671_xn1 XI0_I671_xn I0_pp3_3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15999u ps=0.67999u
    I_MXI0_I671_MN2 (VSS I0_A_3_b3_1 XI0_I671_n1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67999u ps=1.15999u
    I_MXI0_I671_MN4 (XI0_I671_n2 I0_A_2_b3_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
    I_MXI0_I671_MN3 (XI0_I671_xn I0_two3_b3_0 XI0_I671_n2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67999u ps=0.67999u
