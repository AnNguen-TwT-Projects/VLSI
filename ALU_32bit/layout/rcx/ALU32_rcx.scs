    I_MXI0_I1535_MN33 (XI0_I1535_bn2 I0_cm172_2 XI0_I1535_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1535_MN31 (VSS XI0_I1535_s1 XI0_I1535_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1535_MN32 (XI0_I1535_bn2 I0_cm76_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1535_MN55 (VSS XI0_I1535_bcon I0_cm174_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1535_MN38 (XI0_I1535_bn4 XI0_I1535_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1535_MN38_1 (VSS XI0_I1535_s1 XI0_I1535_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1535_MN25 (VSS XI0_I1535_asn XI0_I1535_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1535_MN10 (VSS I0_cm73_0 XI0_I1535_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1535_MN6 (XI0_I1535_an3 I0_cm73_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1535_MN9 (XI0_I1535_asn XI0_I1535_acon XI0_I1535_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1535_MN12 (XI0_I1535_an5 I0_cm75_0 XI0_I1535_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1535_MN11 (XI0_I1535_an4 I0_cm74_0 XI0_I1535_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1535_MN11_1 (XI0_I1535_an5 I0_cm74_0 XI0_I1535_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1535_MN12_1 (XI0_I1535_asn I0_cm75_0 XI0_I1535_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1535_MN10_1 (XI0_I1535_an4 I0_cm73_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1535_MN5 (XI0_I1535_acon I0_cm75_0 XI0_I1535_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1535_MN2 (XI0_I1535_an1 I0_cm74_0 XI0_I1535_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1535_MN1 (VSS I0_cm73_0 XI0_I1535_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1535_MN3 (XI0_I1535_an2 I0_cm73_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1535_MN4 (VSS I0_cm74_0 XI0_I1535_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1535_MN27 (I0_cm174_2 XI0_I1535_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1535_MN7 (XI0_I1535_an3 I0_cm74_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1535_MN8 (VSS I0_cm75_0 XI0_I1535_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN34 (XI0_I1540_bn3 XI0_I1540_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN35 (VSS I0_cm84_1 XI0_I1540_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN36 (XI0_I1540_bn3 I0_cm177_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN37 (XI0_I1540_bsn XI0_I1540_bcon XI0_I1540_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN40 (XI0_I1540_bn5 I0_cm177_2 XI0_I1540_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN39 (XI0_I1540_bn4 I0_cm84_1 XI0_I1540_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN39_1 (XI0_I1540_bn5 I0_cm84_1 XI0_I1540_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN40_1 (XI0_I1540_bsn I0_cm177_2 XI0_I1540_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1540_MN53 (VSS XI0_I1540_bsn I0_cm179_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1540_MN29 (XI0_I1540_bn1 XI0_I1540_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN30 (XI0_I1540_bcon I0_cm84_1 XI0_I1540_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN33 (XI0_I1540_bn2 I0_cm177_2 XI0_I1540_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN31 (VSS XI0_I1540_s1 XI0_I1540_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN32 (XI0_I1540_bn2 I0_cm84_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1540_MN55 (VSS XI0_I1540_bcon I0_cm179_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1540_MN38 (XI0_I1540_bn4 XI0_I1540_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1540_MN38_1 (VSS XI0_I1540_s1 XI0_I1540_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1540_MN25 (VSS XI0_I1540_asn XI0_I1540_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1540_MN10 (VSS I0_cm81_1 XI0_I1540_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN6 (XI0_I1540_an3 I0_cm81_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN9 (XI0_I1540_asn XI0_I1540_acon XI0_I1540_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN12 (XI0_I1540_an5 I0_cm83_1 XI0_I1540_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN11 (XI0_I1540_an4 I0_cm82_1 XI0_I1540_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1540_MN11_1 (XI0_I1540_an5 I0_cm82_1 XI0_I1540_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1540_MN12_1 (XI0_I1540_asn I0_cm83_1 XI0_I1540_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1540_MN10_1 (XI0_I1540_an4 I0_cm81_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN5 (XI0_I1540_acon I0_cm83_1 XI0_I1540_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1540_MN2 (XI0_I1540_an1 I0_cm82_1 XI0_I1540_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN1 (VSS I0_cm81_1 XI0_I1540_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN3 (XI0_I1540_an2 I0_cm81_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN4 (VSS I0_cm82_1 XI0_I1540_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1540_MN27 (I0_cm179_2 XI0_I1540_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1540_MN7 (XI0_I1540_an3 I0_cm82_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1540_MN8 (VSS I0_cm83_1 XI0_I1540_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN34 (XI0_I1451_bn3 XI0_I1451_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN35 (VSS I0_pp9_19 XI0_I1451_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN36 (XI0_I1451_bn3 I0_cm86_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN37 (XI0_I1451_bsn XI0_I1451_bcon XI0_I1451_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN40 (XI0_I1451_bn5 I0_cm86_2 XI0_I1451_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN39 (XI0_I1451_bn4 I0_pp9_19 XI0_I1451_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN39_1 (XI0_I1451_bn5 I0_pp9_19 XI0_I1451_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN40_1 (XI0_I1451_bsn I0_cm86_2 XI0_I1451_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1451_MN53 (VSS XI0_I1451_bsn I0_cm90_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1451_MN29 (XI0_I1451_bn1 XI0_I1451_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN30 (XI0_I1451_bcon I0_pp9_19 XI0_I1451_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN33 (XI0_I1451_bn2 I0_cm86_2 XI0_I1451_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN31 (VSS XI0_I1451_s1 XI0_I1451_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN32 (XI0_I1451_bn2 I0_pp9_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1451_MN55 (VSS XI0_I1451_bcon I0_cm90_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1451_MN38 (XI0_I1451_bn4 XI0_I1451_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1451_MN38_1 (VSS XI0_I1451_s1 XI0_I1451_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1451_MN25 (VSS XI0_I1451_asn XI0_I1451_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1451_MN10 (VSS I0_pp6_25 XI0_I1451_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN6 (XI0_I1451_an3 I0_pp6_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN9 (XI0_I1451_asn XI0_I1451_acon XI0_I1451_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN12 (XI0_I1451_an5 I0_pp8_21 XI0_I1451_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN11 (XI0_I1451_an4 I0_pp7_23 XI0_I1451_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1451_MN11_1 (XI0_I1451_an5 I0_pp7_23 XI0_I1451_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1451_MN12_1 (XI0_I1451_asn I0_pp8_21 XI0_I1451_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1451_MN10_1 (XI0_I1451_an4 I0_pp6_25 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN5 (XI0_I1451_acon I0_pp8_21 XI0_I1451_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1451_MN2 (XI0_I1451_an1 I0_pp7_23 XI0_I1451_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN1 (VSS I0_pp6_25 XI0_I1451_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN3 (XI0_I1451_an2 I0_pp6_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN4 (VSS I0_pp7_23 XI0_I1451_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1451_MN27 (I0_cm90_2 XI0_I1451_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1451_MN7 (XI0_I1451_an3 I0_pp7_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1451_MN8 (VSS I0_pp8_21 XI0_I1451_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN34 (XI0_I1591_bn3 XI0_I1591_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN35 (VSS I0_cm180_0 XI0_I1591_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN36 (XI0_I1591_bn3 I0_cm229_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN37 (XI0_I1591_bsn XI0_I1591_bcon XI0_I1591_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN40 (XI0_I1591_bn5 I0_cm229_2 XI0_I1591_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN39 (XI0_I1591_bn4 I0_cm180_0 XI0_I1591_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN39_1 (XI0_I1591_bn5 I0_cm180_0 XI0_I1591_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN40_1 (XI0_I1591_bsn I0_cm229_2 XI0_I1591_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1591_MN53 (VSS XI0_I1591_bsn I0_cm230_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1591_MN29 (XI0_I1591_bn1 XI0_I1591_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN30 (XI0_I1591_bcon I0_cm180_0 XI0_I1591_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN33 (XI0_I1591_bn2 I0_cm229_2 XI0_I1591_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN31 (VSS XI0_I1591_s1 XI0_I1591_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN32 (XI0_I1591_bn2 I0_cm180_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1591_MN55 (VSS XI0_I1591_bcon I0_cm230_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1591_MN38 (XI0_I1591_bn4 XI0_I1591_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1591_MN38_1 (VSS XI0_I1591_s1 XI0_I1591_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1591_MN25 (VSS XI0_I1591_asn XI0_I1591_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1591_MN10 (VSS I0_cm177_1 XI0_I1591_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN6 (XI0_I1591_an3 I0_cm177_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN9 (XI0_I1591_asn XI0_I1591_acon XI0_I1591_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN12 (XI0_I1591_an5 I0_cm179_0 XI0_I1591_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN11 (XI0_I1591_an4 I0_cm178_1 XI0_I1591_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1591_MN11_1 (XI0_I1591_an5 I0_cm178_1 XI0_I1591_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1591_MN12_1 (XI0_I1591_asn I0_cm179_0 XI0_I1591_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1591_MN10_1 (XI0_I1591_an4 I0_cm177_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN5 (XI0_I1591_acon I0_cm179_0 XI0_I1591_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1591_MN2 (XI0_I1591_an1 I0_cm178_1 XI0_I1591_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN1 (VSS I0_cm177_1 XI0_I1591_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN3 (XI0_I1591_an2 I0_cm177_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN4 (VSS I0_cm178_1 XI0_I1591_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1591_MN27 (I0_cm230_2 XI0_I1591_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1591_MN7 (XI0_I1591_an3 I0_cm178_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1591_MN8 (VSS I0_cm179_0 XI0_I1591_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN34 (XI0_I1468_bn3 XI0_I1468_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN35 (VSS I0_pp8_27 XI0_I1468_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN36 (XI0_I1468_bn3 I0_cm104_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN37 (XI0_I1468_bsn XI0_I1468_bcon XI0_I1468_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN40 (XI0_I1468_bn5 I0_cm104_2 XI0_I1468_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN39 (XI0_I1468_bn4 I0_pp8_27 XI0_I1468_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN39_1 (XI0_I1468_bn5 I0_pp8_27 XI0_I1468_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN40_1 (XI0_I1468_bsn I0_cm104_2 XI0_I1468_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1468_MN53 (VSS XI0_I1468_bsn I0_cm107_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1468_MN29 (XI0_I1468_bn1 XI0_I1468_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN30 (XI0_I1468_bcon I0_pp8_27 XI0_I1468_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN33 (XI0_I1468_bn2 I0_cm104_2 XI0_I1468_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN31 (VSS XI0_I1468_s1 XI0_I1468_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN32 (XI0_I1468_bn2 I0_pp8_27 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1468_MN55 (VSS XI0_I1468_bcon I0_cm107_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1468_MN38 (XI0_I1468_bn4 XI0_I1468_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1468_MN38_1 (VSS XI0_I1468_s1 XI0_I1468_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1468_MN25 (VSS XI0_I1468_asn XI0_I1468_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1468_MN10 (VSS I0_sn5 XI0_I1468_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN6 (XI0_I1468_an3 I0_sn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN9 (XI0_I1468_asn XI0_I1468_acon XI0_I1468_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN12 (XI0_I1468_an5 I0_pp7_29 XI0_I1468_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN11 (XI0_I1468_an4 I0_pp6_31 XI0_I1468_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1468_MN11_1 (XI0_I1468_an5 I0_pp6_31 XI0_I1468_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1468_MN12_1 (XI0_I1468_asn I0_pp7_29 XI0_I1468_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1468_MN10_1 (XI0_I1468_an4 I0_sn5 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN5 (XI0_I1468_acon I0_pp7_29 XI0_I1468_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1468_MN2 (XI0_I1468_an1 I0_pp6_31 XI0_I1468_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN1 (VSS I0_sn5 XI0_I1468_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN3 (XI0_I1468_an2 I0_sn5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN4 (VSS I0_pp6_31 XI0_I1468_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1468_MN27 (I0_cm107_2 XI0_I1468_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1468_MN7 (XI0_I1468_an3 I0_pp6_31 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1468_MN8 (VSS I0_pp7_29 XI0_I1468_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN34 (XI0_I1365_bn3 XI0_I1365_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN35 (VSS I0_pp3_0 XI0_I1365_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN36 (XI0_I1365_bn3 I0_B_7_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN37 (XI0_I1365_bsn XI0_I1365_bcon XI0_I1365_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN40 (XI0_I1365_bn5 I0_B_7_b3_5 XI0_I1365_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN39 (XI0_I1365_bn4 I0_pp3_0 XI0_I1365_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN39_1 (XI0_I1365_bn5 I0_pp3_0 XI0_I1365_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN40_1 (XI0_I1365_bsn I0_B_7_b3_5 XI0_I1365_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1365_MN53 (VSS XI0_I1365_bsn I0_cm4_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1365_MN29 (XI0_I1365_bn1 XI0_I1365_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN30 (XI0_I1365_bcon I0_pp3_0 XI0_I1365_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN33 (XI0_I1365_bn2 I0_B_7_b3_5 XI0_I1365_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN31 (VSS XI0_I1365_s1 XI0_I1365_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN32 (XI0_I1365_bn2 I0_pp3_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1365_MN55 (VSS XI0_I1365_bcon I0_cm4_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1365_MN38 (XI0_I1365_bn4 XI0_I1365_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1365_MN38_1 (VSS XI0_I1365_s1 XI0_I1365_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1365_MN25 (VSS XI0_I1365_asn XI0_I1365_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1365_MN10 (VSS I0_pp0_6 XI0_I1365_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN6 (XI0_I1365_an3 I0_pp0_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN9 (XI0_I1365_asn XI0_I1365_acon XI0_I1365_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN12 (XI0_I1365_an5 I0_pp2_2 XI0_I1365_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN11 (XI0_I1365_an4 I0_pp1_4 XI0_I1365_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1365_MN11_1 (XI0_I1365_an5 I0_pp1_4 XI0_I1365_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1365_MN12_1 (XI0_I1365_asn I0_pp2_2 XI0_I1365_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1365_MN10_1 (XI0_I1365_an4 I0_pp0_6 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN5 (XI0_I1365_acon I0_pp2_2 XI0_I1365_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1365_MN2 (XI0_I1365_an1 I0_pp1_4 XI0_I1365_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN1 (VSS I0_pp0_6 XI0_I1365_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN3 (XI0_I1365_an2 I0_pp0_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN4 (VSS I0_pp1_4 XI0_I1365_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1365_MN27 (I0_cm4_2 XI0_I1365_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1365_MN7 (XI0_I1365_an3 I0_pp1_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1365_MN8 (VSS I0_pp2_2 XI0_I1365_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN34 (XI0_I1388_bn3 XI0_I1388_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN35 (VSS I0_pp7_5 XI0_I1388_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN36 (XI0_I1388_bn3 I0_cm24_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN37 (XI0_I1388_bsn XI0_I1388_bcon XI0_I1388_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN40 (XI0_I1388_bn5 I0_cm24_2 XI0_I1388_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN39 (XI0_I1388_bn4 I0_pp7_5 XI0_I1388_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN39_1 (XI0_I1388_bn5 I0_pp7_5 XI0_I1388_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN40_1 (XI0_I1388_bsn I0_cm24_2 XI0_I1388_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1388_MN53 (VSS XI0_I1388_bsn I0_cm27_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1388_MN29 (XI0_I1388_bn1 XI0_I1388_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN30 (XI0_I1388_bcon I0_pp7_5 XI0_I1388_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN33 (XI0_I1388_bn2 I0_cm24_2 XI0_I1388_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN31 (VSS XI0_I1388_s1 XI0_I1388_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN32 (XI0_I1388_bn2 I0_pp7_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1388_MN55 (VSS XI0_I1388_bcon I0_cm27_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1388_MN38 (XI0_I1388_bn4 XI0_I1388_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1388_MN38_1 (VSS XI0_I1388_s1 XI0_I1388_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1388_MN25 (VSS XI0_I1388_asn XI0_I1388_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1388_MN10 (VSS I0_pp4_11 XI0_I1388_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN6 (XI0_I1388_an3 I0_pp4_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN9 (XI0_I1388_asn XI0_I1388_acon XI0_I1388_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN12 (XI0_I1388_an5 I0_pp6_7 XI0_I1388_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN11 (XI0_I1388_an4 I0_pp5_9 XI0_I1388_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1388_MN11_1 (XI0_I1388_an5 I0_pp5_9 XI0_I1388_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1388_MN12_1 (XI0_I1388_asn I0_pp6_7 XI0_I1388_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1388_MN10_1 (XI0_I1388_an4 I0_pp4_11 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN5 (XI0_I1388_acon I0_pp6_7 XI0_I1388_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1388_MN2 (XI0_I1388_an1 I0_pp5_9 XI0_I1388_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN1 (VSS I0_pp4_11 XI0_I1388_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN3 (XI0_I1388_an2 I0_pp4_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN4 (VSS I0_pp5_9 XI0_I1388_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1388_MN27 (I0_cm27_2 XI0_I1388_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1388_MN7 (XI0_I1388_an3 I0_pp5_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1388_MN8 (VSS I0_pp6_7 XI0_I1388_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN34 (XI0_I1390_bn3 XI0_I1390_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN35 (VSS I0_pp7_6 XI0_I1390_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN36 (XI0_I1390_bn3 I0_cm27_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN37 (XI0_I1390_bsn XI0_I1390_bcon XI0_I1390_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN40 (XI0_I1390_bn5 I0_cm27_2 XI0_I1390_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN39 (XI0_I1390_bn4 I0_pp7_6 XI0_I1390_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN39_1 (XI0_I1390_bn5 I0_pp7_6 XI0_I1390_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN40_1 (XI0_I1390_bsn I0_cm27_2 XI0_I1390_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1390_MN53 (VSS XI0_I1390_bsn I0_cm29_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1390_MN29 (XI0_I1390_bn1 XI0_I1390_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN30 (XI0_I1390_bcon I0_pp7_6 XI0_I1390_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN33 (XI0_I1390_bn2 I0_cm27_2 XI0_I1390_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN31 (VSS XI0_I1390_s1 XI0_I1390_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN32 (XI0_I1390_bn2 I0_pp7_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1390_MN55 (VSS XI0_I1390_bcon I0_cm29_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1390_MN38 (XI0_I1390_bn4 XI0_I1390_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1390_MN38_1 (VSS XI0_I1390_s1 XI0_I1390_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1390_MN25 (VSS XI0_I1390_asn XI0_I1390_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1390_MN10 (VSS I0_pp4_12 XI0_I1390_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN6 (XI0_I1390_an3 I0_pp4_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN9 (XI0_I1390_asn XI0_I1390_acon XI0_I1390_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN12 (XI0_I1390_an5 I0_pp6_8 XI0_I1390_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN11 (XI0_I1390_an4 I0_pp5_10 XI0_I1390_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1390_MN11_1 (XI0_I1390_an5 I0_pp5_10 XI0_I1390_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1390_MN12_1 (XI0_I1390_asn I0_pp6_8 XI0_I1390_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1390_MN10_1 (XI0_I1390_an4 I0_pp4_12 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN5 (XI0_I1390_acon I0_pp6_8 XI0_I1390_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1390_MN2 (XI0_I1390_an1 I0_pp5_10 XI0_I1390_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN1 (VSS I0_pp4_12 XI0_I1390_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN3 (XI0_I1390_an2 I0_pp4_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN4 (VSS I0_pp5_10 XI0_I1390_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1390_MN27 (I0_cm29_2 XI0_I1390_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1390_MN7 (XI0_I1390_an3 I0_pp5_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1390_MN8 (VSS I0_pp6_8 XI0_I1390_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN34 (XI0_I1581_bn3 XI0_I1581_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN35 (VSS I0_fa160_0 XI0_I1581_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN36 (XI0_I1581_bn3 I0_cm219_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN37 (XI0_I1581_bsn XI0_I1581_bcon XI0_I1581_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN40 (XI0_I1581_bn5 I0_cm219_2 XI0_I1581_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN39 (XI0_I1581_bn4 I0_fa160_0 XI0_I1581_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN39_1 (XI0_I1581_bn5 I0_fa160_0 XI0_I1581_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN40_1 (XI0_I1581_bsn I0_cm219_2 XI0_I1581_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1581_MN53 (VSS XI0_I1581_bsn I0_cm220_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1581_MN29 (XI0_I1581_bn1 XI0_I1581_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN30 (XI0_I1581_bcon I0_fa160_0 XI0_I1581_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN33 (XI0_I1581_bn2 I0_cm219_2 XI0_I1581_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN31 (VSS XI0_I1581_s1 XI0_I1581_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN32 (XI0_I1581_bn2 I0_fa160_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1581_MN55 (VSS XI0_I1581_bcon I0_cm220_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1581_MN38 (XI0_I1581_bn4 XI0_I1581_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1581_MN38_1 (VSS XI0_I1581_s1 XI0_I1581_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1581_MN25 (VSS XI0_I1581_asn XI0_I1581_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1581_MN10 (VSS I0_cm157_1 XI0_I1581_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN6 (XI0_I1581_an3 I0_cm157_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN9 (XI0_I1581_asn XI0_I1581_acon XI0_I1581_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN12 (XI0_I1581_an5 I0_cm159_0 XI0_I1581_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN11 (XI0_I1581_an4 I0_fa158_1 XI0_I1581_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1581_MN11_1 (XI0_I1581_an5 I0_fa158_1 XI0_I1581_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1581_MN12_1 (XI0_I1581_asn I0_cm159_0 XI0_I1581_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1581_MN10_1 (XI0_I1581_an4 I0_cm157_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN5 (XI0_I1581_acon I0_cm159_0 XI0_I1581_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1581_MN2 (XI0_I1581_an1 I0_fa158_1 XI0_I1581_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN1 (VSS I0_cm157_1 XI0_I1581_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN3 (XI0_I1581_an2 I0_cm157_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN4 (VSS I0_fa158_1 XI0_I1581_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1581_MN27 (I0_cm220_2 XI0_I1581_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1581_MN7 (XI0_I1581_an3 I0_fa158_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1581_MN8 (VSS I0_cm159_0 XI0_I1581_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN34 (XI0_I1514_bn3 XI0_I1514_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN35 (VSS I0_cm34_0 XI0_I1514_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN36 (XI0_I1514_bn3 I0_cm152_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN37 (XI0_I1514_bsn XI0_I1514_bcon XI0_I1514_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN40 (XI0_I1514_bn5 I0_cm152_2 XI0_I1514_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN39 (XI0_I1514_bn4 I0_cm34_0 XI0_I1514_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN39_1 (XI0_I1514_bn5 I0_cm34_0 XI0_I1514_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN40_1 (XI0_I1514_bsn I0_cm152_2 XI0_I1514_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1514_MN53 (VSS XI0_I1514_bsn I0_cm153_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1514_MN29 (XI0_I1514_bn1 XI0_I1514_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN30 (XI0_I1514_bcon I0_cm34_0 XI0_I1514_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN33 (XI0_I1514_bn2 I0_cm152_2 XI0_I1514_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN31 (VSS XI0_I1514_s1 XI0_I1514_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN32 (XI0_I1514_bn2 I0_cm34_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1514_MN55 (VSS XI0_I1514_bcon I0_cm153_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1514_MN38 (XI0_I1514_bn4 XI0_I1514_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1514_MN38_1 (VSS XI0_I1514_s1 XI0_I1514_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1514_MN25 (VSS XI0_I1514_asn XI0_I1514_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1514_MN10 (VSS I0_cm31_1 XI0_I1514_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN6 (XI0_I1514_an3 I0_cm31_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN9 (XI0_I1514_asn XI0_I1514_acon XI0_I1514_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN12 (XI0_I1514_an5 I0_fa33_1 XI0_I1514_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN11 (XI0_I1514_an4 I0_cm32_1 XI0_I1514_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1514_MN11_1 (XI0_I1514_an5 I0_cm32_1 XI0_I1514_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1514_MN12_1 (XI0_I1514_asn I0_fa33_1 XI0_I1514_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1514_MN10_1 (XI0_I1514_an4 I0_cm31_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN5 (XI0_I1514_acon I0_fa33_1 XI0_I1514_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1514_MN2 (XI0_I1514_an1 I0_cm32_1 XI0_I1514_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN1 (VSS I0_cm31_1 XI0_I1514_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN3 (XI0_I1514_an2 I0_cm31_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN4 (VSS I0_cm32_1 XI0_I1514_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1514_MN27 (I0_cm153_2 XI0_I1514_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1514_MN7 (XI0_I1514_an3 I0_cm32_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1514_MN8 (VSS I0_fa33_1 XI0_I1514_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN34 (XI0_I1416_bn3 XI0_I1416_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN35 (VSS I0_pp11_6 XI0_I1416_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN36 (XI0_I1416_bn3 I0_cm52_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN37 (XI0_I1416_bsn XI0_I1416_bcon XI0_I1416_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN40 (XI0_I1416_bn5 I0_cm52_2 XI0_I1416_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN39 (XI0_I1416_bn4 I0_pp11_6 XI0_I1416_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN39_1 (XI0_I1416_bn5 I0_pp11_6 XI0_I1416_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN40_1 (XI0_I1416_bsn I0_cm52_2 XI0_I1416_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1416_MN53 (VSS XI0_I1416_bsn I0_cm55_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1416_MN29 (XI0_I1416_bn1 XI0_I1416_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN30 (XI0_I1416_bcon I0_pp11_6 XI0_I1416_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN33 (XI0_I1416_bn2 I0_cm52_2 XI0_I1416_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN31 (VSS XI0_I1416_s1 XI0_I1416_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN32 (XI0_I1416_bn2 I0_pp11_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1416_MN55 (VSS XI0_I1416_bcon I0_cm55_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1416_MN38 (XI0_I1416_bn4 XI0_I1416_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1416_MN38_1 (VSS XI0_I1416_s1 XI0_I1416_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1416_MN25 (VSS XI0_I1416_asn XI0_I1416_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1416_MN10 (VSS I0_pp8_12 XI0_I1416_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN6 (XI0_I1416_an3 I0_pp8_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN9 (XI0_I1416_asn XI0_I1416_acon XI0_I1416_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN12 (XI0_I1416_an5 I0_pp10_8 XI0_I1416_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN11 (XI0_I1416_an4 I0_pp9_10 XI0_I1416_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1416_MN11_1 (XI0_I1416_an5 I0_pp9_10 XI0_I1416_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1416_MN12_1 (XI0_I1416_asn I0_pp10_8 XI0_I1416_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1416_MN10_1 (XI0_I1416_an4 I0_pp8_12 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN5 (XI0_I1416_acon I0_pp10_8 XI0_I1416_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1416_MN2 (XI0_I1416_an1 I0_pp9_10 XI0_I1416_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN1 (VSS I0_pp8_12 XI0_I1416_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN3 (XI0_I1416_an2 I0_pp8_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN4 (VSS I0_pp9_10 XI0_I1416_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1416_MN27 (I0_cm55_2 XI0_I1416_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1416_MN7 (XI0_I1416_an3 I0_pp9_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1416_MN8 (VSS I0_pp10_8 XI0_I1416_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN34 (XI0_I1525_bn3 XI0_I1525_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN35 (VSS I0_B_29_b3_5 XI0_I1525_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN36 (XI0_I1525_bn3 I0_cm162_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN37 (XI0_I1525_bsn XI0_I1525_bcon XI0_I1525_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN40 (XI0_I1525_bn5 I0_cm162_2 XI0_I1525_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN39 (XI0_I1525_bn4 I0_B_29_b3_5 XI0_I1525_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN39_1 (XI0_I1525_bn5 I0_B_29_b3_5 XI0_I1525_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN40_1 (XI0_I1525_bsn I0_cm162_2 XI0_I1525_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1525_MN53 (VSS XI0_I1525_bsn I0_cm164_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1525_MN29 (XI0_I1525_bn1 XI0_I1525_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN30 (XI0_I1525_bcon I0_B_29_b3_5 XI0_I1525_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN33 (XI0_I1525_bn2 I0_cm162_2 XI0_I1525_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN31 (VSS XI0_I1525_s1 XI0_I1525_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN32 (XI0_I1525_bn2 I0_B_29_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1525_MN55 (VSS XI0_I1525_bcon I0_cm164_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1525_MN38 (XI0_I1525_bn4 XI0_I1525_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1525_MN38_1 (VSS XI0_I1525_s1 XI0_I1525_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1525_MN25 (VSS XI0_I1525_asn XI0_I1525_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1525_MN10 (VSS I0_cm54_0 XI0_I1525_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN6 (XI0_I1525_an3 I0_cm54_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN9 (XI0_I1525_asn XI0_I1525_acon XI0_I1525_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN12 (XI0_I1525_an5 I0_fa56_0 XI0_I1525_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN11 (XI0_I1525_an4 I0_cm55_0 XI0_I1525_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1525_MN11_1 (XI0_I1525_an5 I0_cm55_0 XI0_I1525_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1525_MN12_1 (XI0_I1525_asn I0_fa56_0 XI0_I1525_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1525_MN10_1 (XI0_I1525_an4 I0_cm54_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN5 (XI0_I1525_acon I0_fa56_0 XI0_I1525_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1525_MN2 (XI0_I1525_an1 I0_cm55_0 XI0_I1525_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN1 (VSS I0_cm54_0 XI0_I1525_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN3 (XI0_I1525_an2 I0_cm54_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN4 (VSS I0_cm55_0 XI0_I1525_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1525_MN27 (I0_cm164_2 XI0_I1525_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1525_MN7 (XI0_I1525_an3 I0_cm55_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1525_MN8 (VSS I0_fa56_0 XI0_I1525_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN34 (XI0_I1527_bn3 XI0_I1527_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN35 (VSS I0_fa60_0 XI0_I1527_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN36 (XI0_I1527_bn3 I0_cm164_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN37 (XI0_I1527_bsn XI0_I1527_bcon XI0_I1527_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN40 (XI0_I1527_bn5 I0_cm164_2 XI0_I1527_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN39 (XI0_I1527_bn4 I0_fa60_0 XI0_I1527_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN39_1 (XI0_I1527_bn5 I0_fa60_0 XI0_I1527_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN40_1 (XI0_I1527_bsn I0_cm164_2 XI0_I1527_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1527_MN53 (VSS XI0_I1527_bsn I0_cm166_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1527_MN29 (XI0_I1527_bn1 XI0_I1527_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN30 (XI0_I1527_bcon I0_fa60_0 XI0_I1527_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN33 (XI0_I1527_bn2 I0_cm164_2 XI0_I1527_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN31 (VSS XI0_I1527_s1 XI0_I1527_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN32 (XI0_I1527_bn2 I0_fa60_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1527_MN55 (VSS XI0_I1527_bcon I0_cm166_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1527_MN38 (XI0_I1527_bn4 XI0_I1527_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1527_MN38_1 (VSS XI0_I1527_s1 XI0_I1527_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1527_MN25 (VSS XI0_I1527_asn XI0_I1527_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1527_MN10 (VSS I0_cm57_0 XI0_I1527_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN6 (XI0_I1527_an3 I0_cm57_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN9 (XI0_I1527_asn XI0_I1527_acon XI0_I1527_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN12 (XI0_I1527_an5 I0_cm59_0 XI0_I1527_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN11 (XI0_I1527_an4 I0_cm58_0 XI0_I1527_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1527_MN11_1 (XI0_I1527_an5 I0_cm58_0 XI0_I1527_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1527_MN12_1 (XI0_I1527_asn I0_cm59_0 XI0_I1527_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1527_MN10_1 (XI0_I1527_an4 I0_cm57_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN5 (XI0_I1527_acon I0_cm59_0 XI0_I1527_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1527_MN2 (XI0_I1527_an1 I0_cm58_0 XI0_I1527_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN1 (VSS I0_cm57_0 XI0_I1527_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN3 (XI0_I1527_an2 I0_cm57_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN4 (VSS I0_cm58_0 XI0_I1527_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1527_MN27 (I0_cm166_2 XI0_I1527_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1527_MN7 (XI0_I1527_an3 I0_cm58_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1527_MN8 (VSS I0_cm59_0 XI0_I1527_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN34 (XI0_I1428_bn3 XI0_I1428_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN35 (VSS I0_pp11_9 XI0_I1428_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN36 (XI0_I1428_bn3 I0_cm63_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN37 (XI0_I1428_bsn XI0_I1428_bcon XI0_I1428_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN40 (XI0_I1428_bn5 I0_cm63_2 XI0_I1428_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN39 (XI0_I1428_bn4 I0_pp11_9 XI0_I1428_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN39_1 (XI0_I1428_bn5 I0_pp11_9 XI0_I1428_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN40_1 (XI0_I1428_bsn I0_cm63_2 XI0_I1428_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1428_MN53 (VSS XI0_I1428_bsn I0_cm67_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1428_MN29 (XI0_I1428_bn1 XI0_I1428_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN30 (XI0_I1428_bcon I0_pp11_9 XI0_I1428_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN33 (XI0_I1428_bn2 I0_cm63_2 XI0_I1428_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN31 (VSS XI0_I1428_s1 XI0_I1428_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN32 (XI0_I1428_bn2 I0_pp11_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1428_MN55 (VSS XI0_I1428_bcon I0_cm67_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1428_MN38 (XI0_I1428_bn4 XI0_I1428_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1428_MN38_1 (VSS XI0_I1428_s1 XI0_I1428_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1428_MN25 (VSS XI0_I1428_asn XI0_I1428_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1428_MN10 (VSS I0_pp8_15 XI0_I1428_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN6 (XI0_I1428_an3 I0_pp8_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN9 (XI0_I1428_asn XI0_I1428_acon XI0_I1428_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN12 (XI0_I1428_an5 I0_pp10_11 XI0_I1428_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN11 (XI0_I1428_an4 I0_pp9_13 XI0_I1428_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1428_MN11_1 (XI0_I1428_an5 I0_pp9_13 XI0_I1428_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1428_MN12_1 (XI0_I1428_asn I0_pp10_11 XI0_I1428_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1428_MN10_1 (XI0_I1428_an4 I0_pp8_15 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN5 (XI0_I1428_acon I0_pp10_11 XI0_I1428_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1428_MN2 (XI0_I1428_an1 I0_pp9_13 XI0_I1428_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN1 (VSS I0_pp8_15 XI0_I1428_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN3 (XI0_I1428_an2 I0_pp8_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN4 (VSS I0_pp9_13 XI0_I1428_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1428_MN27 (I0_cm67_2 XI0_I1428_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1428_MN7 (XI0_I1428_an3 I0_pp9_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1428_MN8 (VSS I0_pp10_11 XI0_I1428_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN34 (XI0_I1436_bn3 XI0_I1436_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN35 (VSS I0_pp11_11 XI0_I1436_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN36 (XI0_I1436_bn3 I0_cm71_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN37 (XI0_I1436_bsn XI0_I1436_bcon XI0_I1436_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN40 (XI0_I1436_bn5 I0_cm71_2 XI0_I1436_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN39 (XI0_I1436_bn4 I0_pp11_11 XI0_I1436_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN39_1 (XI0_I1436_bn5 I0_pp11_11 XI0_I1436_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN40_1 (XI0_I1436_bsn I0_cm71_2 XI0_I1436_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1436_MN53 (VSS XI0_I1436_bsn I0_cm75_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1436_MN29 (XI0_I1436_bn1 XI0_I1436_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN30 (XI0_I1436_bcon I0_pp11_11 XI0_I1436_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN33 (XI0_I1436_bn2 I0_cm71_2 XI0_I1436_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN31 (VSS XI0_I1436_s1 XI0_I1436_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN32 (XI0_I1436_bn2 I0_pp11_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1436_MN55 (VSS XI0_I1436_bcon I0_cm75_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1436_MN38 (XI0_I1436_bn4 XI0_I1436_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1436_MN38_1 (VSS XI0_I1436_s1 XI0_I1436_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1436_MN25 (VSS XI0_I1436_asn XI0_I1436_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1436_MN10 (VSS I0_pp8_17 XI0_I1436_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN6 (XI0_I1436_an3 I0_pp8_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN9 (XI0_I1436_asn XI0_I1436_acon XI0_I1436_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN12 (XI0_I1436_an5 I0_pp10_13 XI0_I1436_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN11 (XI0_I1436_an4 I0_pp9_15 XI0_I1436_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1436_MN11_1 (XI0_I1436_an5 I0_pp9_15 XI0_I1436_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1436_MN12_1 (XI0_I1436_asn I0_pp10_13 XI0_I1436_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1436_MN10_1 (XI0_I1436_an4 I0_pp8_17 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN5 (XI0_I1436_acon I0_pp10_13 XI0_I1436_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1436_MN2 (XI0_I1436_an1 I0_pp9_15 XI0_I1436_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN1 (VSS I0_pp8_17 XI0_I1436_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN3 (XI0_I1436_an2 I0_pp8_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN4 (VSS I0_pp9_15 XI0_I1436_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1436_MN27 (I0_cm75_2 XI0_I1436_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1436_MN7 (XI0_I1436_an3 I0_pp9_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1436_MN8 (VSS I0_pp10_13 XI0_I1436_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN34 (XI0_I1538_bn3 XI0_I1538_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN35 (VSS I0_cm80_1 XI0_I1538_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN36 (XI0_I1538_bn3 I0_cm175_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN37 (XI0_I1538_bsn XI0_I1538_bcon XI0_I1538_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN40 (XI0_I1538_bn5 I0_cm175_2 XI0_I1538_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN39 (XI0_I1538_bn4 I0_cm80_1 XI0_I1538_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN39_1 (XI0_I1538_bn5 I0_cm80_1 XI0_I1538_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN40_1 (XI0_I1538_bsn I0_cm175_2 XI0_I1538_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1538_MN53 (VSS XI0_I1538_bsn I0_cm177_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1538_MN29 (XI0_I1538_bn1 XI0_I1538_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN30 (XI0_I1538_bcon I0_cm80_1 XI0_I1538_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN33 (XI0_I1538_bn2 I0_cm175_2 XI0_I1538_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN31 (VSS XI0_I1538_s1 XI0_I1538_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN32 (XI0_I1538_bn2 I0_cm80_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1538_MN55 (VSS XI0_I1538_bcon I0_cm177_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1538_MN38 (XI0_I1538_bn4 XI0_I1538_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1538_MN38_1 (VSS XI0_I1538_s1 XI0_I1538_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1538_MN25 (VSS XI0_I1538_asn XI0_I1538_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1538_MN10 (VSS I0_cm77_1 XI0_I1538_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN6 (XI0_I1538_an3 I0_cm77_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN9 (XI0_I1538_asn XI0_I1538_acon XI0_I1538_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN12 (XI0_I1538_an5 I0_cm79_1 XI0_I1538_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN11 (XI0_I1538_an4 I0_cm78_1 XI0_I1538_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1538_MN11_1 (XI0_I1538_an5 I0_cm78_1 XI0_I1538_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1538_MN12_1 (XI0_I1538_asn I0_cm79_1 XI0_I1538_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1538_MN10_1 (XI0_I1538_an4 I0_cm77_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN5 (XI0_I1538_acon I0_cm79_1 XI0_I1538_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1538_MN2 (XI0_I1538_an1 I0_cm78_1 XI0_I1538_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN1 (VSS I0_cm77_1 XI0_I1538_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN3 (XI0_I1538_an2 I0_cm77_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN4 (VSS I0_cm78_1 XI0_I1538_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1538_MN27 (I0_cm177_2 XI0_I1538_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1538_MN7 (XI0_I1538_an3 I0_cm78_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1538_MN8 (VSS I0_cm79_1 XI0_I1538_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN34 (XI0_I1542_bn3 XI0_I1542_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN35 (VSS I0_fa88_1 XI0_I1542_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN36 (XI0_I1542_bn3 I0_cm179_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN37 (XI0_I1542_bsn XI0_I1542_bcon XI0_I1542_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN40 (XI0_I1542_bn5 I0_cm179_2 XI0_I1542_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN39 (XI0_I1542_bn4 I0_fa88_1 XI0_I1542_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN39_1 (XI0_I1542_bn5 I0_fa88_1 XI0_I1542_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN40_1 (XI0_I1542_bsn I0_cm179_2 XI0_I1542_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1542_MN53 (VSS XI0_I1542_bsn I0_cm181_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1542_MN29 (XI0_I1542_bn1 XI0_I1542_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN30 (XI0_I1542_bcon I0_fa88_1 XI0_I1542_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN33 (XI0_I1542_bn2 I0_cm179_2 XI0_I1542_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN31 (VSS XI0_I1542_s1 XI0_I1542_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN32 (XI0_I1542_bn2 I0_fa88_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1542_MN55 (VSS XI0_I1542_bcon I0_cm181_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1542_MN38 (XI0_I1542_bn4 XI0_I1542_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1542_MN38_1 (VSS XI0_I1542_s1 XI0_I1542_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1542_MN25 (VSS XI0_I1542_asn XI0_I1542_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1542_MN10 (VSS I0_cm85_1 XI0_I1542_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN6 (XI0_I1542_an3 I0_cm85_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN9 (XI0_I1542_asn XI0_I1542_acon XI0_I1542_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN12 (XI0_I1542_an5 I0_cm87_1 XI0_I1542_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN11 (XI0_I1542_an4 I0_cm86_1 XI0_I1542_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1542_MN11_1 (XI0_I1542_an5 I0_cm86_1 XI0_I1542_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1542_MN12_1 (XI0_I1542_asn I0_cm87_1 XI0_I1542_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1542_MN10_1 (XI0_I1542_an4 I0_cm85_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN5 (XI0_I1542_acon I0_cm87_1 XI0_I1542_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1542_MN2 (XI0_I1542_an1 I0_cm86_1 XI0_I1542_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN1 (VSS I0_cm85_1 XI0_I1542_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN3 (XI0_I1542_an2 I0_cm85_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN4 (VSS I0_cm86_1 XI0_I1542_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1542_MN27 (I0_cm181_2 XI0_I1542_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1542_MN7 (XI0_I1542_an3 I0_cm86_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1542_MN8 (VSS I0_cm87_1 XI0_I1542_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN34 (XI0_I1454_bn3 XI0_I1454_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN35 (VSS I0_pp9_20 XI0_I1454_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN36 (XI0_I1454_bn3 I0_cm90_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN37 (XI0_I1454_bsn XI0_I1454_bcon XI0_I1454_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN40 (XI0_I1454_bn5 I0_cm90_2 XI0_I1454_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN39 (XI0_I1454_bn4 I0_pp9_20 XI0_I1454_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN39_1 (XI0_I1454_bn5 I0_pp9_20 XI0_I1454_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN40_1 (XI0_I1454_bsn I0_cm90_2 XI0_I1454_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1454_MN53 (VSS XI0_I1454_bsn I0_cm93_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1454_MN29 (XI0_I1454_bn1 XI0_I1454_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN30 (XI0_I1454_bcon I0_pp9_20 XI0_I1454_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN33 (XI0_I1454_bn2 I0_cm90_2 XI0_I1454_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN31 (VSS XI0_I1454_s1 XI0_I1454_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN32 (XI0_I1454_bn2 I0_pp9_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1454_MN55 (VSS XI0_I1454_bcon I0_cm93_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1454_MN38 (XI0_I1454_bn4 XI0_I1454_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1454_MN38_1 (VSS XI0_I1454_s1 XI0_I1454_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1454_MN25 (VSS XI0_I1454_asn XI0_I1454_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1454_MN10 (VSS I0_pp6_26 XI0_I1454_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN6 (XI0_I1454_an3 I0_pp6_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN9 (XI0_I1454_asn XI0_I1454_acon XI0_I1454_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN12 (XI0_I1454_an5 I0_pp8_22 XI0_I1454_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN11 (XI0_I1454_an4 I0_pp7_24 XI0_I1454_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1454_MN11_1 (XI0_I1454_an5 I0_pp7_24 XI0_I1454_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1454_MN12_1 (XI0_I1454_asn I0_pp8_22 XI0_I1454_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1454_MN10_1 (XI0_I1454_an4 I0_pp6_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN5 (XI0_I1454_acon I0_pp8_22 XI0_I1454_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1454_MN2 (XI0_I1454_an1 I0_pp7_24 XI0_I1454_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN1 (VSS I0_pp6_26 XI0_I1454_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN3 (XI0_I1454_an2 I0_pp6_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN4 (VSS I0_pp7_24 XI0_I1454_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1454_MN27 (I0_cm93_2 XI0_I1454_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1454_MN7 (XI0_I1454_an3 I0_pp7_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1454_MN8 (VSS I0_pp8_22 XI0_I1454_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN34 (XI0_I1592_bn3 XI0_I1592_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN35 (VSS I0_cm182_0 XI0_I1592_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN36 (XI0_I1592_bn3 I0_cm230_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN37 (XI0_I1592_bsn XI0_I1592_bcon XI0_I1592_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN40 (XI0_I1592_bn5 I0_cm230_2 XI0_I1592_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN39 (XI0_I1592_bn4 I0_cm182_0 XI0_I1592_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN39_1 (XI0_I1592_bn5 I0_cm182_0 XI0_I1592_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN40_1 (XI0_I1592_bsn I0_cm230_2 XI0_I1592_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1592_MN53 (VSS XI0_I1592_bsn I0_cm231_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1592_MN29 (XI0_I1592_bn1 XI0_I1592_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN30 (XI0_I1592_bcon I0_cm182_0 XI0_I1592_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN33 (XI0_I1592_bn2 I0_cm230_2 XI0_I1592_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN31 (VSS XI0_I1592_s1 XI0_I1592_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN32 (XI0_I1592_bn2 I0_cm182_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1592_MN55 (VSS XI0_I1592_bcon I0_cm231_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1592_MN38 (XI0_I1592_bn4 XI0_I1592_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1592_MN38_1 (VSS XI0_I1592_s1 XI0_I1592_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1592_MN25 (VSS XI0_I1592_asn XI0_I1592_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1592_MN10 (VSS I0_cm179_1 XI0_I1592_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN6 (XI0_I1592_an3 I0_cm179_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN9 (XI0_I1592_asn XI0_I1592_acon XI0_I1592_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN12 (XI0_I1592_an5 I0_cm181_0 XI0_I1592_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN11 (XI0_I1592_an4 I0_cm180_1 XI0_I1592_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1592_MN11_1 (XI0_I1592_an5 I0_cm180_1 XI0_I1592_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1592_MN12_1 (XI0_I1592_asn I0_cm181_0 XI0_I1592_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1592_MN10_1 (XI0_I1592_an4 I0_cm179_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN5 (XI0_I1592_acon I0_cm181_0 XI0_I1592_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1592_MN2 (XI0_I1592_an1 I0_cm180_1 XI0_I1592_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN1 (VSS I0_cm179_1 XI0_I1592_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN3 (XI0_I1592_an2 I0_cm179_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN4 (VSS I0_cm180_1 XI0_I1592_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1592_MN27 (I0_cm231_2 XI0_I1592_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1592_MN7 (XI0_I1592_an3 I0_cm180_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1592_MN8 (VSS I0_cm181_0 XI0_I1592_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN34 (XI0_I1544_bn3 XI0_I1544_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN35 (VSS I0_cm92_0 XI0_I1544_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN36 (XI0_I1544_bn3 I0_cm181_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN37 (XI0_I1544_bsn XI0_I1544_bcon XI0_I1544_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN40 (XI0_I1544_bn5 I0_cm181_2 XI0_I1544_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN39 (XI0_I1544_bn4 I0_cm92_0 XI0_I1544_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN39_1 (XI0_I1544_bn5 I0_cm92_0 XI0_I1544_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN40_1 (XI0_I1544_bsn I0_cm181_2 XI0_I1544_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1544_MN53 (VSS XI0_I1544_bsn I0_cm183_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1544_MN29 (XI0_I1544_bn1 XI0_I1544_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN30 (XI0_I1544_bcon I0_cm92_0 XI0_I1544_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN33 (XI0_I1544_bn2 I0_cm181_2 XI0_I1544_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN31 (VSS XI0_I1544_s1 XI0_I1544_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN32 (XI0_I1544_bn2 I0_cm92_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1544_MN55 (VSS XI0_I1544_bcon I0_cm183_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1544_MN38 (XI0_I1544_bn4 XI0_I1544_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1544_MN38_1 (VSS XI0_I1544_s1 XI0_I1544_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1544_MN25 (VSS XI0_I1544_asn XI0_I1544_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1544_MN10 (VSS I0_cm89_1 XI0_I1544_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN6 (XI0_I1544_an3 I0_cm89_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN9 (XI0_I1544_asn XI0_I1544_acon XI0_I1544_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN12 (XI0_I1544_an5 I0_cm91_1 XI0_I1544_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN11 (XI0_I1544_an4 I0_cm90_1 XI0_I1544_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1544_MN11_1 (XI0_I1544_an5 I0_cm90_1 XI0_I1544_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1544_MN12_1 (XI0_I1544_asn I0_cm91_1 XI0_I1544_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1544_MN10_1 (XI0_I1544_an4 I0_cm89_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN5 (XI0_I1544_acon I0_cm91_1 XI0_I1544_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1544_MN2 (XI0_I1544_an1 I0_cm90_1 XI0_I1544_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN1 (VSS I0_cm89_1 XI0_I1544_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN3 (XI0_I1544_an2 I0_cm89_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN4 (VSS I0_cm90_1 XI0_I1544_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1544_MN27 (I0_cm183_2 XI0_I1544_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1544_MN7 (XI0_I1544_an3 I0_cm90_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1544_MN8 (VSS I0_cm91_1 XI0_I1544_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN34 (XI0_I1385_bn3 XI0_I1385_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN35 (VSS I0_pp7_4 XI0_I1385_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN36 (XI0_I1385_bn3 I0_cm22_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN37 (XI0_I1385_bsn XI0_I1385_bcon XI0_I1385_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN40 (XI0_I1385_bn5 I0_cm22_2 XI0_I1385_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN39 (XI0_I1385_bn4 I0_pp7_4 XI0_I1385_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN39_1 (XI0_I1385_bn5 I0_pp7_4 XI0_I1385_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN40_1 (XI0_I1385_bsn I0_cm22_2 XI0_I1385_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1385_MN53 (VSS XI0_I1385_bsn I0_cm24_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1385_MN29 (XI0_I1385_bn1 XI0_I1385_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN30 (XI0_I1385_bcon I0_pp7_4 XI0_I1385_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN33 (XI0_I1385_bn2 I0_cm22_2 XI0_I1385_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN31 (VSS XI0_I1385_s1 XI0_I1385_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN32 (XI0_I1385_bn2 I0_pp7_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1385_MN55 (VSS XI0_I1385_bcon I0_cm24_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1385_MN38 (XI0_I1385_bn4 XI0_I1385_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1385_MN38_1 (VSS XI0_I1385_s1 XI0_I1385_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1385_MN25 (VSS XI0_I1385_asn XI0_I1385_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1385_MN10 (VSS I0_pp4_10 XI0_I1385_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN6 (XI0_I1385_an3 I0_pp4_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN9 (XI0_I1385_asn XI0_I1385_acon XI0_I1385_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN12 (XI0_I1385_an5 I0_pp6_6 XI0_I1385_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN11 (XI0_I1385_an4 I0_pp5_8 XI0_I1385_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1385_MN11_1 (XI0_I1385_an5 I0_pp5_8 XI0_I1385_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1385_MN12_1 (XI0_I1385_asn I0_pp6_6 XI0_I1385_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1385_MN10_1 (XI0_I1385_an4 I0_pp4_10 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN5 (XI0_I1385_acon I0_pp6_6 XI0_I1385_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1385_MN2 (XI0_I1385_an1 I0_pp5_8 XI0_I1385_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN1 (VSS I0_pp4_10 XI0_I1385_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN3 (XI0_I1385_an2 I0_pp4_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN4 (VSS I0_pp5_8 XI0_I1385_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1385_MN27 (I0_cm24_2 XI0_I1385_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1385_MN7 (XI0_I1385_an3 I0_pp5_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1385_MN8 (VSS I0_pp6_6 XI0_I1385_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN34 (XI0_I1582_bn3 XI0_I1582_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN35 (VSS I0_cm162_0 XI0_I1582_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN36 (XI0_I1582_bn3 I0_cm220_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN37 (XI0_I1582_bsn XI0_I1582_bcon XI0_I1582_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN40 (XI0_I1582_bn5 I0_cm220_2 XI0_I1582_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN39 (XI0_I1582_bn4 I0_cm162_0 XI0_I1582_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN39_1 (XI0_I1582_bn5 I0_cm162_0 XI0_I1582_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN40_1 (XI0_I1582_bsn I0_cm220_2 XI0_I1582_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1582_MN53 (VSS XI0_I1582_bsn I0_cm221_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1582_MN29 (XI0_I1582_bn1 XI0_I1582_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN30 (XI0_I1582_bcon I0_cm162_0 XI0_I1582_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN33 (XI0_I1582_bn2 I0_cm220_2 XI0_I1582_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN31 (VSS XI0_I1582_s1 XI0_I1582_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN32 (XI0_I1582_bn2 I0_cm162_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1582_MN55 (VSS XI0_I1582_bcon I0_cm221_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1582_MN38 (XI0_I1582_bn4 XI0_I1582_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1582_MN38_1 (VSS XI0_I1582_s1 XI0_I1582_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1582_MN25 (VSS XI0_I1582_asn XI0_I1582_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1582_MN10 (VSS I0_cm159_1 XI0_I1582_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN6 (XI0_I1582_an3 I0_cm159_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN9 (XI0_I1582_asn XI0_I1582_acon XI0_I1582_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN12 (XI0_I1582_an5 I0_cm161_0 XI0_I1582_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN11 (XI0_I1582_an4 I0_fa160_1 XI0_I1582_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1582_MN11_1 (XI0_I1582_an5 I0_fa160_1 XI0_I1582_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1582_MN12_1 (XI0_I1582_asn I0_cm161_0 XI0_I1582_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1582_MN10_1 (XI0_I1582_an4 I0_cm159_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN5 (XI0_I1582_acon I0_cm161_0 XI0_I1582_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1582_MN2 (XI0_I1582_an1 I0_fa160_1 XI0_I1582_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN1 (VSS I0_cm159_1 XI0_I1582_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN3 (XI0_I1582_an2 I0_cm159_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN4 (VSS I0_fa160_1 XI0_I1582_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1582_MN27 (I0_cm221_2 XI0_I1582_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1582_MN7 (XI0_I1582_an3 I0_fa160_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1582_MN8 (VSS I0_cm161_0 XI0_I1582_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN34 (XI0_I1513_bn3 XI0_I1513_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN35 (VSS I0_cm31_0 XI0_I1513_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN36 (XI0_I1513_bn3 I0_cm151_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN37 (XI0_I1513_bsn XI0_I1513_bcon XI0_I1513_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN40 (XI0_I1513_bn5 I0_cm151_2 XI0_I1513_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN39 (XI0_I1513_bn4 I0_cm31_0 XI0_I1513_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN39_1 (XI0_I1513_bn5 I0_cm31_0 XI0_I1513_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN40_1 (XI0_I1513_bsn I0_cm151_2 XI0_I1513_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1513_MN53 (VSS XI0_I1513_bsn I0_cm152_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1513_MN29 (XI0_I1513_bn1 XI0_I1513_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN30 (XI0_I1513_bcon I0_cm31_0 XI0_I1513_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN33 (XI0_I1513_bn2 I0_cm151_2 XI0_I1513_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN31 (VSS XI0_I1513_s1 XI0_I1513_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN32 (XI0_I1513_bn2 I0_cm31_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1513_MN55 (VSS XI0_I1513_bcon I0_cm152_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1513_MN38 (XI0_I1513_bn4 XI0_I1513_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1513_MN38_1 (VSS XI0_I1513_s1 XI0_I1513_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1513_MN25 (VSS XI0_I1513_asn XI0_I1513_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1513_MN10 (VSS I0_cm28_1 XI0_I1513_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN6 (XI0_I1513_an3 I0_cm28_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN9 (XI0_I1513_asn XI0_I1513_acon XI0_I1513_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN12 (XI0_I1513_an5 I0_fa30_1 XI0_I1513_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN11 (XI0_I1513_an4 I0_cm29_1 XI0_I1513_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1513_MN11_1 (XI0_I1513_an5 I0_cm29_1 XI0_I1513_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1513_MN12_1 (XI0_I1513_asn I0_fa30_1 XI0_I1513_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1513_MN10_1 (XI0_I1513_an4 I0_cm28_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN5 (XI0_I1513_acon I0_fa30_1 XI0_I1513_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1513_MN2 (XI0_I1513_an1 I0_cm29_1 XI0_I1513_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN1 (VSS I0_cm28_1 XI0_I1513_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN3 (XI0_I1513_an2 I0_cm28_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN4 (VSS I0_cm29_1 XI0_I1513_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1513_MN27 (I0_cm152_2 XI0_I1513_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1513_MN7 (XI0_I1513_an3 I0_cm29_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1513_MN8 (VSS I0_fa30_1 XI0_I1513_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN34 (XI0_I1580_bn3 XI0_I1580_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN35 (VSS I0_fa158_0 XI0_I1580_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN36 (XI0_I1580_bn3 I0_cm218_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN37 (XI0_I1580_bsn XI0_I1580_bcon XI0_I1580_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN40 (XI0_I1580_bn5 I0_cm218_2 XI0_I1580_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN39 (XI0_I1580_bn4 I0_fa158_0 XI0_I1580_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN39_1 (XI0_I1580_bn5 I0_fa158_0 XI0_I1580_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN40_1 (XI0_I1580_bsn I0_cm218_2 XI0_I1580_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1580_MN53 (VSS XI0_I1580_bsn I0_cm219_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1580_MN29 (XI0_I1580_bn1 XI0_I1580_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN30 (XI0_I1580_bcon I0_fa158_0 XI0_I1580_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN33 (XI0_I1580_bn2 I0_cm218_2 XI0_I1580_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN31 (VSS XI0_I1580_s1 XI0_I1580_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN32 (XI0_I1580_bn2 I0_fa158_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1580_MN55 (VSS XI0_I1580_bcon I0_cm219_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1580_MN38 (XI0_I1580_bn4 XI0_I1580_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1580_MN38_1 (VSS XI0_I1580_s1 XI0_I1580_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1580_MN25 (VSS XI0_I1580_asn XI0_I1580_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1580_MN10 (VSS I0_cm155_1 XI0_I1580_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN6 (XI0_I1580_an3 I0_cm155_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN9 (XI0_I1580_asn XI0_I1580_acon XI0_I1580_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN12 (XI0_I1580_an5 I0_cm157_0 XI0_I1580_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN11 (XI0_I1580_an4 I0_fa156_1 XI0_I1580_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1580_MN11_1 (XI0_I1580_an5 I0_fa156_1 XI0_I1580_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1580_MN12_1 (XI0_I1580_asn I0_cm157_0 XI0_I1580_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1580_MN10_1 (XI0_I1580_an4 I0_cm155_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN5 (XI0_I1580_acon I0_cm157_0 XI0_I1580_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1580_MN2 (XI0_I1580_an1 I0_fa156_1 XI0_I1580_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN1 (VSS I0_cm155_1 XI0_I1580_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN3 (XI0_I1580_an2 I0_cm155_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN4 (VSS I0_fa156_1 XI0_I1580_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1580_MN27 (I0_cm219_2 XI0_I1580_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1580_MN7 (XI0_I1580_an3 I0_fa156_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1580_MN8 (VSS I0_cm157_0 XI0_I1580_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN34 (XI0_I1413_bn3 XI0_I1413_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN35 (VSS I0_pp11_5 XI0_I1413_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN36 (XI0_I1413_bn3 I0_cm48_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN37 (XI0_I1413_bsn XI0_I1413_bcon XI0_I1413_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN40 (XI0_I1413_bn5 I0_cm48_2 XI0_I1413_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN39 (XI0_I1413_bn4 I0_pp11_5 XI0_I1413_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN39_1 (XI0_I1413_bn5 I0_pp11_5 XI0_I1413_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN40_1 (XI0_I1413_bsn I0_cm48_2 XI0_I1413_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1413_MN53 (VSS XI0_I1413_bsn I0_cm52_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1413_MN29 (XI0_I1413_bn1 XI0_I1413_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN30 (XI0_I1413_bcon I0_pp11_5 XI0_I1413_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN33 (XI0_I1413_bn2 I0_cm48_2 XI0_I1413_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN31 (VSS XI0_I1413_s1 XI0_I1413_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN32 (XI0_I1413_bn2 I0_pp11_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1413_MN55 (VSS XI0_I1413_bcon I0_cm52_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1413_MN38 (XI0_I1413_bn4 XI0_I1413_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1413_MN38_1 (VSS XI0_I1413_s1 XI0_I1413_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1413_MN25 (VSS XI0_I1413_asn XI0_I1413_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1413_MN10 (VSS I0_pp8_11 XI0_I1413_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN6 (XI0_I1413_an3 I0_pp8_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN9 (XI0_I1413_asn XI0_I1413_acon XI0_I1413_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN12 (XI0_I1413_an5 I0_pp10_7 XI0_I1413_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN11 (XI0_I1413_an4 I0_pp9_9 XI0_I1413_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1413_MN11_1 (XI0_I1413_an5 I0_pp9_9 XI0_I1413_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1413_MN12_1 (XI0_I1413_asn I0_pp10_7 XI0_I1413_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1413_MN10_1 (XI0_I1413_an4 I0_pp8_11 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN5 (XI0_I1413_acon I0_pp10_7 XI0_I1413_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1413_MN2 (XI0_I1413_an1 I0_pp9_9 XI0_I1413_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN1 (VSS I0_pp8_11 XI0_I1413_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN3 (XI0_I1413_an2 I0_pp8_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN4 (VSS I0_pp9_9 XI0_I1413_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1413_MN27 (I0_cm52_2 XI0_I1413_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1413_MN7 (XI0_I1413_an3 I0_pp9_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1413_MN8 (VSS I0_pp10_7 XI0_I1413_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN34 (XI0_I1424_bn3 XI0_I1424_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN35 (VSS I0_pp11_8 XI0_I1424_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN36 (XI0_I1424_bn3 I0_cm59_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN37 (XI0_I1424_bsn XI0_I1424_bcon XI0_I1424_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN40 (XI0_I1424_bn5 I0_cm59_2 XI0_I1424_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN39 (XI0_I1424_bn4 I0_pp11_8 XI0_I1424_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN39_1 (XI0_I1424_bn5 I0_pp11_8 XI0_I1424_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN40_1 (XI0_I1424_bsn I0_cm59_2 XI0_I1424_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1424_MN53 (VSS XI0_I1424_bsn I0_cm63_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1424_MN29 (XI0_I1424_bn1 XI0_I1424_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN30 (XI0_I1424_bcon I0_pp11_8 XI0_I1424_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN33 (XI0_I1424_bn2 I0_cm59_2 XI0_I1424_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN31 (VSS XI0_I1424_s1 XI0_I1424_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN32 (XI0_I1424_bn2 I0_pp11_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1424_MN55 (VSS XI0_I1424_bcon I0_cm63_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1424_MN38 (XI0_I1424_bn4 XI0_I1424_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1424_MN38_1 (VSS XI0_I1424_s1 XI0_I1424_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1424_MN25 (VSS XI0_I1424_asn XI0_I1424_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1424_MN10 (VSS I0_pp8_14 XI0_I1424_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN6 (XI0_I1424_an3 I0_pp8_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN9 (XI0_I1424_asn XI0_I1424_acon XI0_I1424_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN12 (XI0_I1424_an5 I0_pp10_10 XI0_I1424_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN11 (XI0_I1424_an4 I0_pp9_12 XI0_I1424_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1424_MN11_1 (XI0_I1424_an5 I0_pp9_12 XI0_I1424_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1424_MN12_1 (XI0_I1424_asn I0_pp10_10 XI0_I1424_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1424_MN10_1 (XI0_I1424_an4 I0_pp8_14 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN5 (XI0_I1424_acon I0_pp10_10 XI0_I1424_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1424_MN2 (XI0_I1424_an1 I0_pp9_12 XI0_I1424_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN1 (VSS I0_pp8_14 XI0_I1424_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN3 (XI0_I1424_an2 I0_pp8_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN4 (VSS I0_pp9_12 XI0_I1424_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1424_MN27 (I0_cm63_2 XI0_I1424_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1424_MN7 (XI0_I1424_an3 I0_pp9_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1424_MN8 (VSS I0_pp10_10 XI0_I1424_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN34 (XI0_I1420_bn3 XI0_I1420_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN35 (VSS I0_pp11_7 XI0_I1420_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN36 (XI0_I1420_bn3 I0_cm55_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN37 (XI0_I1420_bsn XI0_I1420_bcon XI0_I1420_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN40 (XI0_I1420_bn5 I0_cm55_2 XI0_I1420_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN39 (XI0_I1420_bn4 I0_pp11_7 XI0_I1420_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN39_1 (XI0_I1420_bn5 I0_pp11_7 XI0_I1420_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN40_1 (XI0_I1420_bsn I0_cm55_2 XI0_I1420_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1420_MN53 (VSS XI0_I1420_bsn I0_cm59_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1420_MN29 (XI0_I1420_bn1 XI0_I1420_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN30 (XI0_I1420_bcon I0_pp11_7 XI0_I1420_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN33 (XI0_I1420_bn2 I0_cm55_2 XI0_I1420_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN31 (VSS XI0_I1420_s1 XI0_I1420_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN32 (XI0_I1420_bn2 I0_pp11_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1420_MN55 (VSS XI0_I1420_bcon I0_cm59_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1420_MN38 (XI0_I1420_bn4 XI0_I1420_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1420_MN38_1 (VSS XI0_I1420_s1 XI0_I1420_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1420_MN25 (VSS XI0_I1420_asn XI0_I1420_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1420_MN10 (VSS I0_pp8_13 XI0_I1420_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN6 (XI0_I1420_an3 I0_pp8_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN9 (XI0_I1420_asn XI0_I1420_acon XI0_I1420_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN12 (XI0_I1420_an5 I0_pp10_9 XI0_I1420_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN11 (XI0_I1420_an4 I0_pp9_11 XI0_I1420_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1420_MN11_1 (XI0_I1420_an5 I0_pp9_11 XI0_I1420_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1420_MN12_1 (XI0_I1420_asn I0_pp10_9 XI0_I1420_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1420_MN10_1 (XI0_I1420_an4 I0_pp8_13 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN5 (XI0_I1420_acon I0_pp10_9 XI0_I1420_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1420_MN2 (XI0_I1420_an1 I0_pp9_11 XI0_I1420_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN1 (VSS I0_pp8_13 XI0_I1420_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN3 (XI0_I1420_an2 I0_pp8_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN4 (VSS I0_pp9_11 XI0_I1420_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1420_MN27 (I0_cm59_2 XI0_I1420_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1420_MN7 (XI0_I1420_an3 I0_pp9_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1420_MN8 (VSS I0_pp10_9 XI0_I1420_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN34 (XI0_I1432_bn3 XI0_I1432_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN35 (VSS I0_pp11_10 XI0_I1432_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN36 (XI0_I1432_bn3 I0_cm67_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN37 (XI0_I1432_bsn XI0_I1432_bcon XI0_I1432_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN40 (XI0_I1432_bn5 I0_cm67_2 XI0_I1432_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN39 (XI0_I1432_bn4 I0_pp11_10 XI0_I1432_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN39_1 (XI0_I1432_bn5 I0_pp11_10 XI0_I1432_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN40_1 (XI0_I1432_bsn I0_cm67_2 XI0_I1432_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1432_MN53 (VSS XI0_I1432_bsn I0_cm71_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1432_MN29 (XI0_I1432_bn1 XI0_I1432_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN30 (XI0_I1432_bcon I0_pp11_10 XI0_I1432_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN33 (XI0_I1432_bn2 I0_cm67_2 XI0_I1432_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN31 (VSS XI0_I1432_s1 XI0_I1432_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN32 (XI0_I1432_bn2 I0_pp11_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1432_MN55 (VSS XI0_I1432_bcon I0_cm71_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1432_MN38 (XI0_I1432_bn4 XI0_I1432_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1432_MN38_1 (VSS XI0_I1432_s1 XI0_I1432_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1432_MN25 (VSS XI0_I1432_asn XI0_I1432_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1432_MN10 (VSS I0_pp8_16 XI0_I1432_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN6 (XI0_I1432_an3 I0_pp8_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN9 (XI0_I1432_asn XI0_I1432_acon XI0_I1432_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN12 (XI0_I1432_an5 I0_pp10_12 XI0_I1432_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN11 (XI0_I1432_an4 I0_pp9_14 XI0_I1432_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1432_MN11_1 (XI0_I1432_an5 I0_pp9_14 XI0_I1432_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1432_MN12_1 (XI0_I1432_asn I0_pp10_12 XI0_I1432_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1432_MN10_1 (XI0_I1432_an4 I0_pp8_16 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN5 (XI0_I1432_acon I0_pp10_12 XI0_I1432_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1432_MN2 (XI0_I1432_an1 I0_pp9_14 XI0_I1432_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN1 (VSS I0_pp8_16 XI0_I1432_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN3 (XI0_I1432_an2 I0_pp8_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN4 (VSS I0_pp9_14 XI0_I1432_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1432_MN27 (I0_cm71_2 XI0_I1432_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1432_MN7 (XI0_I1432_an3 I0_pp9_14 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1432_MN8 (VSS I0_pp10_12 XI0_I1432_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN34 (XI0_I1440_bn3 XI0_I1440_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN35 (VSS I0_pp11_12 XI0_I1440_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN36 (XI0_I1440_bn3 I0_cm75_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN37 (XI0_I1440_bsn XI0_I1440_bcon XI0_I1440_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN40 (XI0_I1440_bn5 I0_cm75_2 XI0_I1440_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN39 (XI0_I1440_bn4 I0_pp11_12 XI0_I1440_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN39_1 (XI0_I1440_bn5 I0_pp11_12 XI0_I1440_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN40_1 (XI0_I1440_bsn I0_cm75_2 XI0_I1440_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1440_MN53 (VSS XI0_I1440_bsn I0_cm79_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1440_MN29 (XI0_I1440_bn1 XI0_I1440_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN30 (XI0_I1440_bcon I0_pp11_12 XI0_I1440_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN33 (XI0_I1440_bn2 I0_cm75_2 XI0_I1440_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN31 (VSS XI0_I1440_s1 XI0_I1440_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN32 (XI0_I1440_bn2 I0_pp11_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1440_MN55 (VSS XI0_I1440_bcon I0_cm79_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1440_MN38 (XI0_I1440_bn4 XI0_I1440_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1440_MN38_1 (VSS XI0_I1440_s1 XI0_I1440_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1440_MN25 (VSS XI0_I1440_asn XI0_I1440_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1440_MN10 (VSS I0_pp8_18 XI0_I1440_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN6 (XI0_I1440_an3 I0_pp8_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN9 (XI0_I1440_asn XI0_I1440_acon XI0_I1440_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN12 (XI0_I1440_an5 I0_pp10_14 XI0_I1440_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN11 (XI0_I1440_an4 I0_pp9_16 XI0_I1440_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1440_MN11_1 (XI0_I1440_an5 I0_pp9_16 XI0_I1440_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1440_MN12_1 (XI0_I1440_asn I0_pp10_14 XI0_I1440_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1440_MN10_1 (XI0_I1440_an4 I0_pp8_18 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN5 (XI0_I1440_acon I0_pp10_14 XI0_I1440_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1440_MN2 (XI0_I1440_an1 I0_pp9_16 XI0_I1440_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN1 (VSS I0_pp8_18 XI0_I1440_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN3 (XI0_I1440_an2 I0_pp8_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN4 (VSS I0_pp9_16 XI0_I1440_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1440_MN27 (I0_cm79_2 XI0_I1440_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1440_MN7 (XI0_I1440_an3 I0_pp9_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1440_MN8 (VSS I0_pp10_14 XI0_I1440_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN34 (XI0_I1444_bn3 XI0_I1444_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN35 (VSS I0_pp11_13 XI0_I1444_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN36 (XI0_I1444_bn3 I0_cm79_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN37 (XI0_I1444_bsn XI0_I1444_bcon XI0_I1444_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN40 (XI0_I1444_bn5 I0_cm79_2 XI0_I1444_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN39 (XI0_I1444_bn4 I0_pp11_13 XI0_I1444_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN39_1 (XI0_I1444_bn5 I0_pp11_13 XI0_I1444_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN40_1 (XI0_I1444_bsn I0_cm79_2 XI0_I1444_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1444_MN53 (VSS XI0_I1444_bsn I0_cm83_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1444_MN29 (XI0_I1444_bn1 XI0_I1444_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN30 (XI0_I1444_bcon I0_pp11_13 XI0_I1444_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN33 (XI0_I1444_bn2 I0_cm79_2 XI0_I1444_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN31 (VSS XI0_I1444_s1 XI0_I1444_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN32 (XI0_I1444_bn2 I0_pp11_13 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1444_MN55 (VSS XI0_I1444_bcon I0_cm83_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1444_MN38 (XI0_I1444_bn4 XI0_I1444_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1444_MN38_1 (VSS XI0_I1444_s1 XI0_I1444_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1444_MN25 (VSS XI0_I1444_asn XI0_I1444_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1444_MN10 (VSS I0_pp8_19 XI0_I1444_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN6 (XI0_I1444_an3 I0_pp8_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN9 (XI0_I1444_asn XI0_I1444_acon XI0_I1444_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN12 (XI0_I1444_an5 I0_pp10_15 XI0_I1444_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN11 (XI0_I1444_an4 I0_pp9_17 XI0_I1444_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1444_MN11_1 (XI0_I1444_an5 I0_pp9_17 XI0_I1444_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1444_MN12_1 (XI0_I1444_asn I0_pp10_15 XI0_I1444_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1444_MN10_1 (XI0_I1444_an4 I0_pp8_19 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN5 (XI0_I1444_acon I0_pp10_15 XI0_I1444_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1444_MN2 (XI0_I1444_an1 I0_pp9_17 XI0_I1444_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN1 (VSS I0_pp8_19 XI0_I1444_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN3 (XI0_I1444_an2 I0_pp8_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN4 (VSS I0_pp9_17 XI0_I1444_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1444_MN27 (I0_cm83_2 XI0_I1444_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1444_MN7 (XI0_I1444_an3 I0_pp9_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1444_MN8 (VSS I0_pp10_15 XI0_I1444_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN34 (XI0_I1543_bn3 XI0_I1543_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN35 (VSS I0_pp14_9 XI0_I1543_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN36 (XI0_I1543_bn3 I0_cm180_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN37 (XI0_I1543_bsn XI0_I1543_bcon XI0_I1543_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN40 (XI0_I1543_bn5 I0_cm180_2 XI0_I1543_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN39 (XI0_I1543_bn4 I0_pp14_9 XI0_I1543_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN39_1 (XI0_I1543_bn5 I0_pp14_9 XI0_I1543_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN40_1 (XI0_I1543_bsn I0_cm180_2 XI0_I1543_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1543_MN53 (VSS XI0_I1543_bsn I0_cm182_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1543_MN29 (XI0_I1543_bn1 XI0_I1543_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN30 (XI0_I1543_bcon I0_pp14_9 XI0_I1543_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN33 (XI0_I1543_bn2 I0_cm180_2 XI0_I1543_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN31 (VSS XI0_I1543_s1 XI0_I1543_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN32 (XI0_I1543_bn2 I0_pp14_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1543_MN55 (VSS XI0_I1543_bcon I0_cm182_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1543_MN38 (XI0_I1543_bn4 XI0_I1543_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1543_MN38_1 (VSS XI0_I1543_s1 XI0_I1543_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1543_MN25 (VSS XI0_I1543_asn XI0_I1543_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1543_MN10 (VSS I0_cm89_0 XI0_I1543_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN6 (XI0_I1543_an3 I0_cm89_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN9 (XI0_I1543_asn XI0_I1543_acon XI0_I1543_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN12 (XI0_I1543_an5 I0_cm91_0 XI0_I1543_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN11 (XI0_I1543_an4 I0_cm90_0 XI0_I1543_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1543_MN11_1 (XI0_I1543_an5 I0_cm90_0 XI0_I1543_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1543_MN12_1 (XI0_I1543_asn I0_cm91_0 XI0_I1543_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1543_MN10_1 (XI0_I1543_an4 I0_cm89_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN5 (XI0_I1543_acon I0_cm91_0 XI0_I1543_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1543_MN2 (XI0_I1543_an1 I0_cm90_0 XI0_I1543_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN1 (VSS I0_cm89_0 XI0_I1543_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN3 (XI0_I1543_an2 I0_cm89_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN4 (VSS I0_cm90_0 XI0_I1543_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1543_MN27 (I0_cm182_2 XI0_I1543_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1543_MN7 (XI0_I1543_an3 I0_cm90_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1543_MN8 (VSS I0_cm91_0 XI0_I1543_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN34 (XI0_I1546_bn3 XI0_I1546_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN35 (VSS I0_cm95_0 XI0_I1546_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN36 (XI0_I1546_bn3 I0_cm183_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN37 (XI0_I1546_bsn XI0_I1546_bcon XI0_I1546_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN40 (XI0_I1546_bn5 I0_cm183_2 XI0_I1546_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN39 (XI0_I1546_bn4 I0_cm95_0 XI0_I1546_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN39_1 (XI0_I1546_bn5 I0_cm95_0 XI0_I1546_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN40_1 (XI0_I1546_bsn I0_cm183_2 XI0_I1546_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1546_MN53 (VSS XI0_I1546_bsn I0_cm185_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1546_MN29 (XI0_I1546_bn1 XI0_I1546_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN30 (XI0_I1546_bcon I0_cm95_0 XI0_I1546_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN33 (XI0_I1546_bn2 I0_cm183_2 XI0_I1546_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN31 (VSS XI0_I1546_s1 XI0_I1546_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN32 (XI0_I1546_bn2 I0_cm95_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1546_MN55 (VSS XI0_I1546_bcon I0_cm185_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1546_MN38 (XI0_I1546_bn4 XI0_I1546_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1546_MN38_1 (VSS XI0_I1546_s1 XI0_I1546_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1546_MN25 (VSS XI0_I1546_asn XI0_I1546_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1546_MN10 (VSS I0_cm92_1 XI0_I1546_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN6 (XI0_I1546_an3 I0_cm92_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN9 (XI0_I1546_asn XI0_I1546_acon XI0_I1546_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN12 (XI0_I1546_an5 I0_cm94_1 XI0_I1546_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN11 (XI0_I1546_an4 I0_cm93_1 XI0_I1546_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1546_MN11_1 (XI0_I1546_an5 I0_cm93_1 XI0_I1546_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1546_MN12_1 (XI0_I1546_asn I0_cm94_1 XI0_I1546_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1546_MN10_1 (XI0_I1546_an4 I0_cm92_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN5 (XI0_I1546_acon I0_cm94_1 XI0_I1546_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1546_MN2 (XI0_I1546_an1 I0_cm93_1 XI0_I1546_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN1 (VSS I0_cm92_1 XI0_I1546_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN3 (XI0_I1546_an2 I0_cm92_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN4 (VSS I0_cm93_1 XI0_I1546_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1546_MN27 (I0_cm185_2 XI0_I1546_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1546_MN7 (XI0_I1546_an3 I0_cm93_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1546_MN8 (VSS I0_cm94_1 XI0_I1546_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN34 (XI0_I1377_bn3 XI0_I1377_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN35 (VSS I0_pp7_0 XI0_I1377_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN36 (XI0_I1377_bn3 I0_B_15_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN37 (XI0_I1377_bsn XI0_I1377_bcon XI0_I1377_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN40 (XI0_I1377_bn5 I0_B_15_b3_5 XI0_I1377_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN39 (XI0_I1377_bn4 I0_pp7_0 XI0_I1377_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN39_1 (XI0_I1377_bn5 I0_pp7_0 XI0_I1377_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN40_1 (XI0_I1377_bsn I0_B_15_b3_5 XI0_I1377_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1377_MN53 (VSS XI0_I1377_bsn I0_cm16_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1377_MN29 (XI0_I1377_bn1 XI0_I1377_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN30 (XI0_I1377_bcon I0_pp7_0 XI0_I1377_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN33 (XI0_I1377_bn2 I0_B_15_b3_5 XI0_I1377_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN31 (VSS XI0_I1377_s1 XI0_I1377_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN32 (XI0_I1377_bn2 I0_pp7_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1377_MN55 (VSS XI0_I1377_bcon I0_cm16_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1377_MN38 (XI0_I1377_bn4 XI0_I1377_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1377_MN38_1 (VSS XI0_I1377_s1 XI0_I1377_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1377_MN25 (VSS XI0_I1377_asn XI0_I1377_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1377_MN10 (VSS I0_pp4_6 XI0_I1377_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN6 (XI0_I1377_an3 I0_pp4_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN9 (XI0_I1377_asn XI0_I1377_acon XI0_I1377_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN12 (XI0_I1377_an5 I0_pp6_2 XI0_I1377_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN11 (XI0_I1377_an4 I0_pp5_4 XI0_I1377_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1377_MN11_1 (XI0_I1377_an5 I0_pp5_4 XI0_I1377_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1377_MN12_1 (XI0_I1377_asn I0_pp6_2 XI0_I1377_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1377_MN10_1 (XI0_I1377_an4 I0_pp4_6 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN5 (XI0_I1377_acon I0_pp6_2 XI0_I1377_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1377_MN2 (XI0_I1377_an1 I0_pp5_4 XI0_I1377_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN1 (VSS I0_pp4_6 XI0_I1377_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN3 (XI0_I1377_an2 I0_pp4_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN4 (VSS I0_pp5_4 XI0_I1377_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1377_MN27 (I0_cm16_2 XI0_I1377_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1377_MN7 (XI0_I1377_an3 I0_pp5_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1377_MN8 (VSS I0_pp6_2 XI0_I1377_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN34 (XI0_I1510_bn3 XI0_I1510_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN35 (VSS I0_cm26_0 XI0_I1510_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN36 (XI0_I1510_bn3 I0_cm148_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN37 (XI0_I1510_bsn XI0_I1510_bcon XI0_I1510_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN40 (XI0_I1510_bn5 I0_cm148_2 XI0_I1510_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN39 (XI0_I1510_bn4 I0_cm26_0 XI0_I1510_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN39_1 (XI0_I1510_bn5 I0_cm26_0 XI0_I1510_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN40_1 (XI0_I1510_bsn I0_cm148_2 XI0_I1510_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1510_MN53 (VSS XI0_I1510_bsn I0_cm149_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1510_MN29 (XI0_I1510_bn1 XI0_I1510_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN30 (XI0_I1510_bcon I0_cm26_0 XI0_I1510_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN33 (XI0_I1510_bn2 I0_cm148_2 XI0_I1510_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN31 (VSS XI0_I1510_s1 XI0_I1510_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN32 (XI0_I1510_bn2 I0_cm26_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1510_MN55 (VSS XI0_I1510_bcon I0_cm149_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1510_MN38 (XI0_I1510_bn4 XI0_I1510_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1510_MN38_1 (VSS XI0_I1510_s1 XI0_I1510_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1510_MN25 (VSS XI0_I1510_asn XI0_I1510_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1510_MN10 (VSS I0_cm23_1 XI0_I1510_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN6 (XI0_I1510_an3 I0_cm23_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN9 (XI0_I1510_asn XI0_I1510_acon XI0_I1510_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN12 (XI0_I1510_an5 I0_fa25_1 XI0_I1510_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN11 (XI0_I1510_an4 I0_cm24_1 XI0_I1510_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1510_MN11_1 (XI0_I1510_an5 I0_cm24_1 XI0_I1510_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1510_MN12_1 (XI0_I1510_asn I0_fa25_1 XI0_I1510_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1510_MN10_1 (XI0_I1510_an4 I0_cm23_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN5 (XI0_I1510_acon I0_fa25_1 XI0_I1510_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1510_MN2 (XI0_I1510_an1 I0_cm24_1 XI0_I1510_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN1 (VSS I0_cm23_1 XI0_I1510_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN3 (XI0_I1510_an2 I0_cm23_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN4 (VSS I0_cm24_1 XI0_I1510_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1510_MN27 (I0_cm149_2 XI0_I1510_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1510_MN7 (XI0_I1510_an3 I0_cm24_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1510_MN8 (VSS I0_fa25_1 XI0_I1510_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN34 (XI0_I1383_bn3 XI0_I1383_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN35 (VSS I0_pp7_3 XI0_I1383_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN36 (XI0_I1383_bn3 I0_cm20_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN37 (XI0_I1383_bsn XI0_I1383_bcon XI0_I1383_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN40 (XI0_I1383_bn5 I0_cm20_2 XI0_I1383_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN39 (XI0_I1383_bn4 I0_pp7_3 XI0_I1383_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN39_1 (XI0_I1383_bn5 I0_pp7_3 XI0_I1383_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN40_1 (XI0_I1383_bsn I0_cm20_2 XI0_I1383_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1383_MN53 (VSS XI0_I1383_bsn I0_cm22_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1383_MN29 (XI0_I1383_bn1 XI0_I1383_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN30 (XI0_I1383_bcon I0_pp7_3 XI0_I1383_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN33 (XI0_I1383_bn2 I0_cm20_2 XI0_I1383_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN31 (VSS XI0_I1383_s1 XI0_I1383_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN32 (XI0_I1383_bn2 I0_pp7_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1383_MN55 (VSS XI0_I1383_bcon I0_cm22_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1383_MN38 (XI0_I1383_bn4 XI0_I1383_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1383_MN38_1 (VSS XI0_I1383_s1 XI0_I1383_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1383_MN25 (VSS XI0_I1383_asn XI0_I1383_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1383_MN10 (VSS I0_pp4_9 XI0_I1383_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN6 (XI0_I1383_an3 I0_pp4_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN9 (XI0_I1383_asn XI0_I1383_acon XI0_I1383_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN12 (XI0_I1383_an5 I0_pp6_5 XI0_I1383_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN11 (XI0_I1383_an4 I0_pp5_7 XI0_I1383_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1383_MN11_1 (XI0_I1383_an5 I0_pp5_7 XI0_I1383_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1383_MN12_1 (XI0_I1383_asn I0_pp6_5 XI0_I1383_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1383_MN10_1 (XI0_I1383_an4 I0_pp4_9 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN5 (XI0_I1383_acon I0_pp6_5 XI0_I1383_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1383_MN2 (XI0_I1383_an1 I0_pp5_7 XI0_I1383_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN1 (VSS I0_pp4_9 XI0_I1383_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN3 (XI0_I1383_an2 I0_pp4_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN4 (VSS I0_pp5_7 XI0_I1383_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1383_MN27 (I0_cm22_2 XI0_I1383_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1383_MN7 (XI0_I1383_an3 I0_pp5_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1383_MN8 (VSS I0_pp6_5 XI0_I1383_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN34 (XI0_I1509_bn3 XI0_I1509_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN35 (VSS I0_cm24_0 XI0_I1509_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN36 (XI0_I1509_bn3 I0_cm147_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN37 (XI0_I1509_bsn XI0_I1509_bcon XI0_I1509_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN40 (XI0_I1509_bn5 I0_cm147_2 XI0_I1509_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN39 (XI0_I1509_bn4 I0_cm24_0 XI0_I1509_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN39_1 (XI0_I1509_bn5 I0_cm24_0 XI0_I1509_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN40_1 (XI0_I1509_bsn I0_cm147_2 XI0_I1509_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1509_MN53 (VSS XI0_I1509_bsn I0_cm148_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1509_MN29 (XI0_I1509_bn1 XI0_I1509_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN30 (XI0_I1509_bcon I0_cm24_0 XI0_I1509_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN33 (XI0_I1509_bn2 I0_cm147_2 XI0_I1509_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN31 (VSS XI0_I1509_s1 XI0_I1509_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN32 (XI0_I1509_bn2 I0_cm24_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1509_MN55 (VSS XI0_I1509_bcon I0_cm148_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1509_MN38 (XI0_I1509_bn4 XI0_I1509_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1509_MN38_1 (VSS XI0_I1509_s1 XI0_I1509_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1509_MN25 (VSS XI0_I1509_asn XI0_I1509_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1509_MN10 (VSS I0_cm21_1 XI0_I1509_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN6 (XI0_I1509_an3 I0_cm21_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN9 (XI0_I1509_asn XI0_I1509_acon XI0_I1509_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN12 (XI0_I1509_an5 I0_cm23_0 XI0_I1509_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN11 (XI0_I1509_an4 I0_cm22_1 XI0_I1509_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1509_MN11_1 (XI0_I1509_an5 I0_cm22_1 XI0_I1509_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1509_MN12_1 (XI0_I1509_asn I0_cm23_0 XI0_I1509_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1509_MN10_1 (XI0_I1509_an4 I0_cm21_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN5 (XI0_I1509_acon I0_cm23_0 XI0_I1509_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1509_MN2 (XI0_I1509_an1 I0_cm22_1 XI0_I1509_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN1 (VSS I0_cm21_1 XI0_I1509_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN3 (XI0_I1509_an2 I0_cm21_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN4 (VSS I0_cm22_1 XI0_I1509_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1509_MN27 (I0_cm148_2 XI0_I1509_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1509_MN7 (XI0_I1509_an3 I0_cm22_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1509_MN8 (VSS I0_cm23_0 XI0_I1509_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN34 (XI0_I1578_bn3 XI0_I1578_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN35 (VSS I0_cm39_0 XI0_I1578_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN36 (XI0_I1578_bn3 I0_cm216_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN37 (XI0_I1578_bsn XI0_I1578_bcon XI0_I1578_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN40 (XI0_I1578_bn5 I0_cm216_2 XI0_I1578_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN39 (XI0_I1578_bn4 I0_cm39_0 XI0_I1578_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN39_1 (XI0_I1578_bn5 I0_cm39_0 XI0_I1578_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN40_1 (XI0_I1578_bsn I0_cm216_2 XI0_I1578_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1578_MN53 (VSS XI0_I1578_bsn I0_cm217_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1578_MN29 (XI0_I1578_bn1 XI0_I1578_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN30 (XI0_I1578_bcon I0_cm39_0 XI0_I1578_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN33 (XI0_I1578_bn2 I0_cm216_2 XI0_I1578_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN31 (VSS XI0_I1578_s1 XI0_I1578_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN32 (XI0_I1578_bn2 I0_cm39_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1578_MN55 (VSS XI0_I1578_bcon I0_cm217_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1578_MN38 (XI0_I1578_bn4 XI0_I1578_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1578_MN38_1 (VSS XI0_I1578_s1 XI0_I1578_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1578_MN25 (VSS XI0_I1578_asn XI0_I1578_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1578_MN10 (VSS I0_cm153_1 XI0_I1578_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN6 (XI0_I1578_an3 I0_cm153_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN9 (XI0_I1578_asn XI0_I1578_acon XI0_I1578_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN12 (XI0_I1578_an5 I0_cm38_0 XI0_I1578_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN11 (XI0_I1578_an4 I0_cm154_0 XI0_I1578_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1578_MN11_1 (XI0_I1578_an5 I0_cm154_0 XI0_I1578_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1578_MN12_1 (XI0_I1578_asn I0_cm38_0 XI0_I1578_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1578_MN10_1 (XI0_I1578_an4 I0_cm153_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN5 (XI0_I1578_acon I0_cm38_0 XI0_I1578_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1578_MN2 (XI0_I1578_an1 I0_cm154_0 XI0_I1578_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN1 (VSS I0_cm153_1 XI0_I1578_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN3 (XI0_I1578_an2 I0_cm153_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN4 (VSS I0_cm154_0 XI0_I1578_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1578_MN27 (I0_cm217_2 XI0_I1578_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1578_MN7 (XI0_I1578_an3 I0_cm154_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1578_MN8 (VSS I0_cm38_0 XI0_I1578_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN34 (XI0_I1406_bn3 XI0_I1406_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN35 (VSS I0_pp11_3 XI0_I1406_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN36 (XI0_I1406_bn3 I0_cm42_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN37 (XI0_I1406_bsn XI0_I1406_bcon XI0_I1406_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN40 (XI0_I1406_bn5 I0_cm42_2 XI0_I1406_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN39 (XI0_I1406_bn4 I0_pp11_3 XI0_I1406_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN39_1 (XI0_I1406_bn5 I0_pp11_3 XI0_I1406_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN40_1 (XI0_I1406_bsn I0_cm42_2 XI0_I1406_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1406_MN53 (VSS XI0_I1406_bsn I0_cm45_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1406_MN29 (XI0_I1406_bn1 XI0_I1406_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN30 (XI0_I1406_bcon I0_pp11_3 XI0_I1406_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN33 (XI0_I1406_bn2 I0_cm42_2 XI0_I1406_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN31 (VSS XI0_I1406_s1 XI0_I1406_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN32 (XI0_I1406_bn2 I0_pp11_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1406_MN55 (VSS XI0_I1406_bcon I0_cm45_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1406_MN38 (XI0_I1406_bn4 XI0_I1406_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1406_MN38_1 (VSS XI0_I1406_s1 XI0_I1406_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1406_MN25 (VSS XI0_I1406_asn XI0_I1406_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1406_MN10 (VSS I0_pp8_9 XI0_I1406_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN6 (XI0_I1406_an3 I0_pp8_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN9 (XI0_I1406_asn XI0_I1406_acon XI0_I1406_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN12 (XI0_I1406_an5 I0_pp10_5 XI0_I1406_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN11 (XI0_I1406_an4 I0_pp9_7 XI0_I1406_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1406_MN11_1 (XI0_I1406_an5 I0_pp9_7 XI0_I1406_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1406_MN12_1 (XI0_I1406_asn I0_pp10_5 XI0_I1406_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1406_MN10_1 (XI0_I1406_an4 I0_pp8_9 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN5 (XI0_I1406_acon I0_pp10_5 XI0_I1406_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1406_MN2 (XI0_I1406_an1 I0_pp9_7 XI0_I1406_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN1 (VSS I0_pp8_9 XI0_I1406_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN3 (XI0_I1406_an2 I0_pp8_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN4 (VSS I0_pp9_7 XI0_I1406_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1406_MN27 (I0_cm45_2 XI0_I1406_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1406_MN7 (XI0_I1406_an3 I0_pp9_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1406_MN8 (VSS I0_pp10_5 XI0_I1406_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN34 (XI0_I1409_bn3 XI0_I1409_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN35 (VSS I0_pp11_4 XI0_I1409_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN36 (XI0_I1409_bn3 I0_cm45_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN37 (XI0_I1409_bsn XI0_I1409_bcon XI0_I1409_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN40 (XI0_I1409_bn5 I0_cm45_2 XI0_I1409_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN39 (XI0_I1409_bn4 I0_pp11_4 XI0_I1409_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN39_1 (XI0_I1409_bn5 I0_pp11_4 XI0_I1409_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN40_1 (XI0_I1409_bsn I0_cm45_2 XI0_I1409_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1409_MN53 (VSS XI0_I1409_bsn I0_cm48_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1409_MN29 (XI0_I1409_bn1 XI0_I1409_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN30 (XI0_I1409_bcon I0_pp11_4 XI0_I1409_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN33 (XI0_I1409_bn2 I0_cm45_2 XI0_I1409_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN31 (VSS XI0_I1409_s1 XI0_I1409_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN32 (XI0_I1409_bn2 I0_pp11_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1409_MN55 (VSS XI0_I1409_bcon I0_cm48_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1409_MN38 (XI0_I1409_bn4 XI0_I1409_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1409_MN38_1 (VSS XI0_I1409_s1 XI0_I1409_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1409_MN25 (VSS XI0_I1409_asn XI0_I1409_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1409_MN10 (VSS I0_pp8_10 XI0_I1409_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN6 (XI0_I1409_an3 I0_pp8_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN9 (XI0_I1409_asn XI0_I1409_acon XI0_I1409_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN12 (XI0_I1409_an5 I0_pp10_6 XI0_I1409_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN11 (XI0_I1409_an4 I0_pp9_8 XI0_I1409_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1409_MN11_1 (XI0_I1409_an5 I0_pp9_8 XI0_I1409_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1409_MN12_1 (XI0_I1409_asn I0_pp10_6 XI0_I1409_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1409_MN10_1 (XI0_I1409_an4 I0_pp8_10 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN5 (XI0_I1409_acon I0_pp10_6 XI0_I1409_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1409_MN2 (XI0_I1409_an1 I0_pp9_8 XI0_I1409_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN1 (VSS I0_pp8_10 XI0_I1409_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN3 (XI0_I1409_an2 I0_pp8_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN4 (VSS I0_pp9_8 XI0_I1409_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1409_MN27 (I0_cm48_2 XI0_I1409_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1409_MN7 (XI0_I1409_an3 I0_pp9_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1409_MN8 (VSS I0_pp10_6 XI0_I1409_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN34 (XI0_I1448_bn3 XI0_I1448_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN35 (VSS I0_pp12_12 XI0_I1448_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN36 (XI0_I1448_bn3 I0_cm83_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN37 (XI0_I1448_bsn XI0_I1448_bcon XI0_I1448_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN40 (XI0_I1448_bn5 I0_cm83_2 XI0_I1448_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN39 (XI0_I1448_bn4 I0_pp12_12 XI0_I1448_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN39_1 (XI0_I1448_bn5 I0_pp12_12 XI0_I1448_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN40_1 (XI0_I1448_bsn I0_cm83_2 XI0_I1448_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1448_MN53 (VSS XI0_I1448_bsn I0_cm87_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1448_MN29 (XI0_I1448_bn1 XI0_I1448_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN30 (XI0_I1448_bcon I0_pp12_12 XI0_I1448_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN33 (XI0_I1448_bn2 I0_cm83_2 XI0_I1448_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN31 (VSS XI0_I1448_s1 XI0_I1448_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN32 (XI0_I1448_bn2 I0_pp12_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1448_MN55 (VSS XI0_I1448_bcon I0_cm87_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1448_MN38 (XI0_I1448_bn4 XI0_I1448_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1448_MN38_1 (VSS XI0_I1448_s1 XI0_I1448_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1448_MN25 (VSS XI0_I1448_asn XI0_I1448_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1448_MN10 (VSS I0_pp9_18 XI0_I1448_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN6 (XI0_I1448_an3 I0_pp9_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN9 (XI0_I1448_asn XI0_I1448_acon XI0_I1448_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN12 (XI0_I1448_an5 I0_pp11_14 XI0_I1448_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN11 (XI0_I1448_an4 I0_pp10_16 XI0_I1448_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1448_MN11_1 (XI0_I1448_an5 I0_pp10_16 XI0_I1448_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1448_MN12_1 (XI0_I1448_asn I0_pp11_14 XI0_I1448_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1448_MN10_1 (XI0_I1448_an4 I0_pp9_18 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN5 (XI0_I1448_acon I0_pp11_14 XI0_I1448_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1448_MN2 (XI0_I1448_an1 I0_pp10_16 XI0_I1448_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN1 (VSS I0_pp9_18 XI0_I1448_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN3 (XI0_I1448_an2 I0_pp9_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN4 (VSS I0_pp10_16 XI0_I1448_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1448_MN27 (I0_cm87_2 XI0_I1448_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1448_MN7 (XI0_I1448_an3 I0_pp10_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1448_MN8 (VSS I0_pp11_14 XI0_I1448_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN34 (XI0_I1593_bn3 XI0_I1593_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN35 (VSS I0_cm184_0 XI0_I1593_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN36 (XI0_I1593_bn3 I0_cm231_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN37 (XI0_I1593_bsn XI0_I1593_bcon XI0_I1593_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN40 (XI0_I1593_bn5 I0_cm231_2 XI0_I1593_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN39 (XI0_I1593_bn4 I0_cm184_0 XI0_I1593_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN39_1 (XI0_I1593_bn5 I0_cm184_0 XI0_I1593_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN40_1 (XI0_I1593_bsn I0_cm231_2 XI0_I1593_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1593_MN53 (VSS XI0_I1593_bsn I0_cm232_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1593_MN29 (XI0_I1593_bn1 XI0_I1593_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN30 (XI0_I1593_bcon I0_cm184_0 XI0_I1593_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN33 (XI0_I1593_bn2 I0_cm231_2 XI0_I1593_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN31 (VSS XI0_I1593_s1 XI0_I1593_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN32 (XI0_I1593_bn2 I0_cm184_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1593_MN55 (VSS XI0_I1593_bcon I0_cm232_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1593_MN38 (XI0_I1593_bn4 XI0_I1593_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1593_MN38_1 (VSS XI0_I1593_s1 XI0_I1593_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1593_MN25 (VSS XI0_I1593_asn XI0_I1593_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1593_MN10 (VSS I0_cm181_1 XI0_I1593_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN6 (XI0_I1593_an3 I0_cm181_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN9 (XI0_I1593_asn XI0_I1593_acon XI0_I1593_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN12 (XI0_I1593_an5 I0_cm183_0 XI0_I1593_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN11 (XI0_I1593_an4 I0_cm182_1 XI0_I1593_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1593_MN11_1 (XI0_I1593_an5 I0_cm182_1 XI0_I1593_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1593_MN12_1 (XI0_I1593_asn I0_cm183_0 XI0_I1593_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1593_MN10_1 (XI0_I1593_an4 I0_cm181_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN5 (XI0_I1593_acon I0_cm183_0 XI0_I1593_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1593_MN2 (XI0_I1593_an1 I0_cm182_1 XI0_I1593_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN1 (VSS I0_cm181_1 XI0_I1593_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN3 (XI0_I1593_an2 I0_cm181_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN4 (VSS I0_cm182_1 XI0_I1593_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1593_MN27 (I0_cm232_2 XI0_I1593_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1593_MN7 (XI0_I1593_an3 I0_cm182_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1593_MN8 (VSS I0_cm183_0 XI0_I1593_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN34 (XI0_I1502_bn3 XI0_I1502_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN35 (VSS I0_pp4_3 XI0_I1502_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN36 (XI0_I1502_bn3 I0_pp5_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN37 (XI0_I1502_bsn XI0_I1502_bcon XI0_I1502_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN40 (XI0_I1502_bn5 I0_pp5_1 XI0_I1502_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN39 (XI0_I1502_bn4 I0_pp4_3 XI0_I1502_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN39_1 (XI0_I1502_bn5 I0_pp4_3 XI0_I1502_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN40_1 (XI0_I1502_bsn I0_pp5_1 XI0_I1502_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1502_MN53 (VSS XI0_I1502_bsn I0_cm141_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1502_MN29 (XI0_I1502_bn1 XI0_I1502_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN30 (XI0_I1502_bcon I0_pp4_3 XI0_I1502_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN33 (XI0_I1502_bn2 I0_pp5_1 XI0_I1502_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN31 (VSS XI0_I1502_s1 XI0_I1502_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN32 (XI0_I1502_bn2 I0_pp4_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1502_MN55 (VSS XI0_I1502_bcon I0_cm141_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1502_MN38 (XI0_I1502_bn4 XI0_I1502_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1502_MN38_1 (VSS XI0_I1502_s1 XI0_I1502_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1502_MN25 (VSS XI0_I1502_asn XI0_I1502_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1502_MN10 (VSS I0_cm8_1 XI0_I1502_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN6 (XI0_I1502_an3 I0_cm8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN9 (XI0_I1502_asn XI0_I1502_acon XI0_I1502_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN12 (XI0_I1502_an5 I0_cm10_0 XI0_I1502_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN11 (XI0_I1502_an4 I0_fa9_1 XI0_I1502_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1502_MN11_1 (XI0_I1502_an5 I0_fa9_1 XI0_I1502_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1502_MN12_1 (XI0_I1502_asn I0_cm10_0 XI0_I1502_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1502_MN10_1 (XI0_I1502_an4 I0_cm8_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN5 (XI0_I1502_acon I0_cm10_0 XI0_I1502_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1502_MN2 (XI0_I1502_an1 I0_fa9_1 XI0_I1502_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN1 (VSS I0_cm8_1 XI0_I1502_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN3 (XI0_I1502_an2 I0_cm8_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN4 (VSS I0_fa9_1 XI0_I1502_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1502_MN27 (I0_cm141_2 XI0_I1502_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1502_MN7 (XI0_I1502_an3 I0_fa9_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1502_MN8 (VSS I0_cm10_0 XI0_I1502_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN34 (XI0_I1503_bn3 XI0_I1503_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN35 (VSS I0_B_13_b3_5 XI0_I1503_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN36 (XI0_I1503_bn3 I0_cm141_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN37 (XI0_I1503_bsn XI0_I1503_bcon XI0_I1503_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN40 (XI0_I1503_bn5 I0_cm141_2 XI0_I1503_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN39 (XI0_I1503_bn4 I0_B_13_b3_5 XI0_I1503_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN39_1 (XI0_I1503_bn5 I0_B_13_b3_5 XI0_I1503_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN40_1 (XI0_I1503_bsn I0_cm141_2 XI0_I1503_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1503_MN53 (VSS XI0_I1503_bsn I0_cm142_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1503_MN29 (XI0_I1503_bn1 XI0_I1503_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN30 (XI0_I1503_bcon I0_B_13_b3_5 XI0_I1503_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN33 (XI0_I1503_bn2 I0_cm141_2 XI0_I1503_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN31 (VSS XI0_I1503_s1 XI0_I1503_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN32 (XI0_I1503_bn2 I0_B_13_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1503_MN55 (VSS XI0_I1503_bcon I0_cm142_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1503_MN38 (XI0_I1503_bn4 XI0_I1503_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1503_MN38_1 (VSS XI0_I1503_s1 XI0_I1503_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1503_MN25 (VSS XI0_I1503_asn XI0_I1503_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1503_MN10 (VSS I0_cm10_1 XI0_I1503_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN6 (XI0_I1503_an3 I0_cm10_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN9 (XI0_I1503_asn XI0_I1503_acon XI0_I1503_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN12 (XI0_I1503_an5 I0_fa12_0 XI0_I1503_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN11 (XI0_I1503_an4 I0_cm11_0 XI0_I1503_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1503_MN11_1 (XI0_I1503_an5 I0_cm11_0 XI0_I1503_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1503_MN12_1 (XI0_I1503_asn I0_fa12_0 XI0_I1503_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1503_MN10_1 (XI0_I1503_an4 I0_cm10_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN5 (XI0_I1503_acon I0_fa12_0 XI0_I1503_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1503_MN2 (XI0_I1503_an1 I0_cm11_0 XI0_I1503_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN1 (VSS I0_cm10_1 XI0_I1503_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN3 (XI0_I1503_an2 I0_cm10_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN4 (VSS I0_cm11_0 XI0_I1503_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1503_MN27 (I0_cm142_2 XI0_I1503_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1503_MN7 (XI0_I1503_an3 I0_cm11_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1503_MN8 (VSS I0_fa12_0 XI0_I1503_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN34 (XI0_I1381_bn3 XI0_I1381_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN35 (VSS I0_pp7_2 XI0_I1381_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN36 (XI0_I1381_bn3 I0_cm18_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN37 (XI0_I1381_bsn XI0_I1381_bcon XI0_I1381_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN40 (XI0_I1381_bn5 I0_cm18_2 XI0_I1381_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN39 (XI0_I1381_bn4 I0_pp7_2 XI0_I1381_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN39_1 (XI0_I1381_bn5 I0_pp7_2 XI0_I1381_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN40_1 (XI0_I1381_bsn I0_cm18_2 XI0_I1381_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1381_MN53 (VSS XI0_I1381_bsn I0_cm20_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1381_MN29 (XI0_I1381_bn1 XI0_I1381_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN30 (XI0_I1381_bcon I0_pp7_2 XI0_I1381_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN33 (XI0_I1381_bn2 I0_cm18_2 XI0_I1381_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN31 (VSS XI0_I1381_s1 XI0_I1381_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN32 (XI0_I1381_bn2 I0_pp7_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1381_MN55 (VSS XI0_I1381_bcon I0_cm20_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1381_MN38 (XI0_I1381_bn4 XI0_I1381_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1381_MN38_1 (VSS XI0_I1381_s1 XI0_I1381_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1381_MN25 (VSS XI0_I1381_asn XI0_I1381_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1381_MN10 (VSS I0_pp4_8 XI0_I1381_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN6 (XI0_I1381_an3 I0_pp4_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN9 (XI0_I1381_asn XI0_I1381_acon XI0_I1381_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN12 (XI0_I1381_an5 I0_pp6_4 XI0_I1381_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN11 (XI0_I1381_an4 I0_pp5_6 XI0_I1381_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1381_MN11_1 (XI0_I1381_an5 I0_pp5_6 XI0_I1381_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1381_MN12_1 (XI0_I1381_asn I0_pp6_4 XI0_I1381_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1381_MN10_1 (XI0_I1381_an4 I0_pp4_8 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN5 (XI0_I1381_acon I0_pp6_4 XI0_I1381_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1381_MN2 (XI0_I1381_an1 I0_pp5_6 XI0_I1381_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN1 (VSS I0_pp4_8 XI0_I1381_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN3 (XI0_I1381_an2 I0_pp4_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN4 (VSS I0_pp5_6 XI0_I1381_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1381_MN27 (I0_cm20_2 XI0_I1381_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1381_MN7 (XI0_I1381_an3 I0_pp5_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1381_MN8 (VSS I0_pp6_4 XI0_I1381_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN34 (XI0_I1379_bn3 XI0_I1379_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN35 (VSS I0_pp7_1 XI0_I1379_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN36 (XI0_I1379_bn3 I0_cm16_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN37 (XI0_I1379_bsn XI0_I1379_bcon XI0_I1379_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN40 (XI0_I1379_bn5 I0_cm16_2 XI0_I1379_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN39 (XI0_I1379_bn4 I0_pp7_1 XI0_I1379_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN39_1 (XI0_I1379_bn5 I0_pp7_1 XI0_I1379_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN40_1 (XI0_I1379_bsn I0_cm16_2 XI0_I1379_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1379_MN53 (VSS XI0_I1379_bsn I0_cm18_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1379_MN29 (XI0_I1379_bn1 XI0_I1379_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN30 (XI0_I1379_bcon I0_pp7_1 XI0_I1379_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN33 (XI0_I1379_bn2 I0_cm16_2 XI0_I1379_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN31 (VSS XI0_I1379_s1 XI0_I1379_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN32 (XI0_I1379_bn2 I0_pp7_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1379_MN55 (VSS XI0_I1379_bcon I0_cm18_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1379_MN38 (XI0_I1379_bn4 XI0_I1379_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1379_MN38_1 (VSS XI0_I1379_s1 XI0_I1379_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1379_MN25 (VSS XI0_I1379_asn XI0_I1379_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1379_MN10 (VSS I0_pp4_7 XI0_I1379_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN6 (XI0_I1379_an3 I0_pp4_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN9 (XI0_I1379_asn XI0_I1379_acon XI0_I1379_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN12 (XI0_I1379_an5 I0_pp6_3 XI0_I1379_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN11 (XI0_I1379_an4 I0_pp5_5 XI0_I1379_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1379_MN11_1 (XI0_I1379_an5 I0_pp5_5 XI0_I1379_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1379_MN12_1 (XI0_I1379_asn I0_pp6_3 XI0_I1379_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1379_MN10_1 (XI0_I1379_an4 I0_pp4_7 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN5 (XI0_I1379_acon I0_pp6_3 XI0_I1379_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1379_MN2 (XI0_I1379_an1 I0_pp5_5 XI0_I1379_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN1 (VSS I0_pp4_7 XI0_I1379_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN3 (XI0_I1379_an2 I0_pp4_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN4 (VSS I0_pp5_5 XI0_I1379_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1379_MN27 (I0_cm18_2 XI0_I1379_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1379_MN7 (XI0_I1379_an3 I0_pp5_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1379_MN8 (VSS I0_pp6_3 XI0_I1379_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN34 (XI0_I1577_bn3 XI0_I1577_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN35 (VSS I0_cm36_0 XI0_I1577_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN36 (XI0_I1577_bn3 I0_cm215_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN37 (XI0_I1577_bsn XI0_I1577_bcon XI0_I1577_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN40 (XI0_I1577_bn5 I0_cm215_2 XI0_I1577_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN39 (XI0_I1577_bn4 I0_cm36_0 XI0_I1577_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN39_1 (XI0_I1577_bn5 I0_cm36_0 XI0_I1577_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN40_1 (XI0_I1577_bsn I0_cm215_2 XI0_I1577_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1577_MN53 (VSS XI0_I1577_bsn I0_cm216_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1577_MN29 (XI0_I1577_bn1 XI0_I1577_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN30 (XI0_I1577_bcon I0_cm36_0 XI0_I1577_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN33 (XI0_I1577_bn2 I0_cm215_2 XI0_I1577_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN31 (VSS XI0_I1577_s1 XI0_I1577_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN32 (XI0_I1577_bn2 I0_cm36_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1577_MN55 (VSS XI0_I1577_bcon I0_cm216_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1577_MN38 (XI0_I1577_bn4 XI0_I1577_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1577_MN38_1 (VSS XI0_I1577_s1 XI0_I1577_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1577_MN25 (VSS XI0_I1577_asn XI0_I1577_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1577_MN10 (VSS I0_cm152_1 XI0_I1577_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN6 (XI0_I1577_an3 I0_cm152_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN9 (XI0_I1577_asn XI0_I1577_acon XI0_I1577_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN12 (XI0_I1577_an5 I0_cm35_0 XI0_I1577_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN11 (XI0_I1577_an4 I0_cm153_0 XI0_I1577_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1577_MN11_1 (XI0_I1577_an5 I0_cm153_0 XI0_I1577_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1577_MN12_1 (XI0_I1577_asn I0_cm35_0 XI0_I1577_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1577_MN10_1 (XI0_I1577_an4 I0_cm152_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN5 (XI0_I1577_acon I0_cm35_0 XI0_I1577_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1577_MN2 (XI0_I1577_an1 I0_cm153_0 XI0_I1577_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN1 (VSS I0_cm152_1 XI0_I1577_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN3 (XI0_I1577_an2 I0_cm152_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN4 (VSS I0_cm153_0 XI0_I1577_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1577_MN27 (I0_cm216_2 XI0_I1577_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1577_MN7 (XI0_I1577_an3 I0_cm153_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1577_MN8 (VSS I0_cm35_0 XI0_I1577_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN34 (XI0_I1576_bn3 XI0_I1576_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN35 (VSS I0_fa33_0 XI0_I1576_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN36 (XI0_I1576_bn3 I0_cm214_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN37 (XI0_I1576_bsn XI0_I1576_bcon XI0_I1576_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN40 (XI0_I1576_bn5 I0_cm214_2 XI0_I1576_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN39 (XI0_I1576_bn4 I0_fa33_0 XI0_I1576_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN39_1 (XI0_I1576_bn5 I0_fa33_0 XI0_I1576_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN40_1 (XI0_I1576_bsn I0_cm214_2 XI0_I1576_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1576_MN53 (VSS XI0_I1576_bsn I0_cm215_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1576_MN29 (XI0_I1576_bn1 XI0_I1576_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN30 (XI0_I1576_bcon I0_fa33_0 XI0_I1576_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN33 (XI0_I1576_bn2 I0_cm214_2 XI0_I1576_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN31 (VSS XI0_I1576_s1 XI0_I1576_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN32 (XI0_I1576_bn2 I0_fa33_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1576_MN55 (VSS XI0_I1576_bcon I0_cm215_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1576_MN38 (XI0_I1576_bn4 XI0_I1576_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1576_MN38_1 (VSS XI0_I1576_s1 XI0_I1576_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1576_MN25 (VSS XI0_I1576_asn XI0_I1576_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1576_MN10 (VSS I0_cm151_1 XI0_I1576_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN6 (XI0_I1576_an3 I0_cm151_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN9 (XI0_I1576_asn XI0_I1576_acon XI0_I1576_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN12 (XI0_I1576_an5 I0_cm32_0 XI0_I1576_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN11 (XI0_I1576_an4 I0_cm152_0 XI0_I1576_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1576_MN11_1 (XI0_I1576_an5 I0_cm152_0 XI0_I1576_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1576_MN12_1 (XI0_I1576_asn I0_cm32_0 XI0_I1576_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1576_MN10_1 (XI0_I1576_an4 I0_cm151_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN5 (XI0_I1576_acon I0_cm32_0 XI0_I1576_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1576_MN2 (XI0_I1576_an1 I0_cm152_0 XI0_I1576_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN1 (VSS I0_cm151_1 XI0_I1576_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN3 (XI0_I1576_an2 I0_cm151_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN4 (VSS I0_cm152_0 XI0_I1576_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1576_MN27 (I0_cm215_2 XI0_I1576_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1576_MN7 (XI0_I1576_an3 I0_cm152_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1576_MN8 (VSS I0_cm32_0 XI0_I1576_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN34 (XI0_I1579_bn3 XI0_I1579_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN35 (VSS I0_B_25_b3_5 XI0_I1579_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN36 (XI0_I1579_bn3 I0_cm217_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN37 (XI0_I1579_bsn XI0_I1579_bcon XI0_I1579_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN40 (XI0_I1579_bn5 I0_cm217_2 XI0_I1579_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN39 (XI0_I1579_bn4 I0_B_25_b3_5 XI0_I1579_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN39_1 (XI0_I1579_bn5 I0_B_25_b3_5 XI0_I1579_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN40_1 (XI0_I1579_bsn I0_cm217_2 XI0_I1579_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1579_MN53 (VSS XI0_I1579_bsn I0_cm218_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1579_MN29 (XI0_I1579_bn1 XI0_I1579_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN30 (XI0_I1579_bcon I0_B_25_b3_5 XI0_I1579_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN33 (XI0_I1579_bn2 I0_cm217_2 XI0_I1579_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN31 (VSS XI0_I1579_s1 XI0_I1579_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN32 (XI0_I1579_bn2 I0_B_25_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1579_MN55 (VSS XI0_I1579_bcon I0_cm218_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1579_MN38 (XI0_I1579_bn4 XI0_I1579_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1579_MN38_1 (VSS XI0_I1579_s1 XI0_I1579_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1579_MN25 (VSS XI0_I1579_asn XI0_I1579_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1579_MN10 (VSS I0_cm154_1 XI0_I1579_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN6 (XI0_I1579_an3 I0_cm154_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN9 (XI0_I1579_asn XI0_I1579_acon XI0_I1579_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN12 (XI0_I1579_an5 I0_fa156_0 XI0_I1579_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN11 (XI0_I1579_an4 I0_cm155_0 XI0_I1579_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1579_MN11_1 (XI0_I1579_an5 I0_cm155_0 XI0_I1579_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1579_MN12_1 (XI0_I1579_asn I0_fa156_0 XI0_I1579_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1579_MN10_1 (XI0_I1579_an4 I0_cm154_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN5 (XI0_I1579_acon I0_fa156_0 XI0_I1579_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1579_MN2 (XI0_I1579_an1 I0_cm155_0 XI0_I1579_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN1 (VSS I0_cm154_1 XI0_I1579_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN3 (XI0_I1579_an2 I0_cm154_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN4 (VSS I0_cm155_0 XI0_I1579_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1579_MN27 (I0_cm218_2 XI0_I1579_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1579_MN7 (XI0_I1579_an3 I0_cm155_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1579_MN8 (VSS I0_fa156_0 XI0_I1579_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN34 (XI0_I1445_bn3 XI0_I1445_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN35 (VSS I0_pp15_5 XI0_I1445_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN36 (XI0_I1445_bn3 I0_cm80_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN37 (XI0_I1445_bsn XI0_I1445_bcon XI0_I1445_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN40 (XI0_I1445_bn5 I0_cm80_2 XI0_I1445_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN39 (XI0_I1445_bn4 I0_pp15_5 XI0_I1445_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN39_1 (XI0_I1445_bn5 I0_pp15_5 XI0_I1445_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN40_1 (XI0_I1445_bsn I0_cm80_2 XI0_I1445_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1445_MN53 (VSS XI0_I1445_bsn I0_cm84_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1445_MN29 (XI0_I1445_bn1 XI0_I1445_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN30 (XI0_I1445_bcon I0_pp15_5 XI0_I1445_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN33 (XI0_I1445_bn2 I0_cm80_2 XI0_I1445_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN31 (VSS XI0_I1445_s1 XI0_I1445_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN32 (XI0_I1445_bn2 I0_pp15_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1445_MN55 (VSS XI0_I1445_bcon I0_cm84_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1445_MN38 (XI0_I1445_bn4 XI0_I1445_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1445_MN38_1 (VSS XI0_I1445_s1 XI0_I1445_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1445_MN25 (VSS XI0_I1445_asn XI0_I1445_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1445_MN10 (VSS I0_pp12_11 XI0_I1445_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN6 (XI0_I1445_an3 I0_pp12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN9 (XI0_I1445_asn XI0_I1445_acon XI0_I1445_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN12 (XI0_I1445_an5 I0_pp14_7 XI0_I1445_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN11 (XI0_I1445_an4 I0_pp13_9 XI0_I1445_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1445_MN11_1 (XI0_I1445_an5 I0_pp13_9 XI0_I1445_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1445_MN12_1 (XI0_I1445_asn I0_pp14_7 XI0_I1445_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1445_MN10_1 (XI0_I1445_an4 I0_pp12_11 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN5 (XI0_I1445_acon I0_pp14_7 XI0_I1445_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1445_MN2 (XI0_I1445_an1 I0_pp13_9 XI0_I1445_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN1 (VSS I0_pp12_11 XI0_I1445_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN3 (XI0_I1445_an2 I0_pp12_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN4 (VSS I0_pp13_9 XI0_I1445_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1445_MN27 (I0_cm84_2 XI0_I1445_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1445_MN7 (XI0_I1445_an3 I0_pp13_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1445_MN8 (VSS I0_pp14_7 XI0_I1445_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN34 (XI0_I1545_bn3 XI0_I1545_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN35 (VSS I0_pp15_8 XI0_I1545_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN36 (XI0_I1545_bn3 I0_cm182_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN37 (XI0_I1545_bsn XI0_I1545_bcon XI0_I1545_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN40 (XI0_I1545_bn5 I0_cm182_2 XI0_I1545_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN39 (XI0_I1545_bn4 I0_pp15_8 XI0_I1545_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN39_1 (XI0_I1545_bn5 I0_pp15_8 XI0_I1545_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN40_1 (XI0_I1545_bsn I0_cm182_2 XI0_I1545_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1545_MN53 (VSS XI0_I1545_bsn I0_cm184_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1545_MN29 (XI0_I1545_bn1 XI0_I1545_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN30 (XI0_I1545_bcon I0_pp15_8 XI0_I1545_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN33 (XI0_I1545_bn2 I0_cm182_2 XI0_I1545_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN31 (VSS XI0_I1545_s1 XI0_I1545_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN32 (XI0_I1545_bn2 I0_pp15_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1545_MN55 (VSS XI0_I1545_bcon I0_cm184_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1545_MN38 (XI0_I1545_bn4 XI0_I1545_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1545_MN38_1 (VSS XI0_I1545_s1 XI0_I1545_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1545_MN25 (VSS XI0_I1545_asn XI0_I1545_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1545_MN10 (VSS I0_cm93_0 XI0_I1545_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN6 (XI0_I1545_an3 I0_cm93_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN9 (XI0_I1545_asn XI0_I1545_acon XI0_I1545_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN12 (XI0_I1545_an5 I0_pp14_10 XI0_I1545_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN11 (XI0_I1545_an4 I0_cm94_0 XI0_I1545_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1545_MN11_1 (XI0_I1545_an5 I0_cm94_0 XI0_I1545_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1545_MN12_1 (XI0_I1545_asn I0_pp14_10 XI0_I1545_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1545_MN10_1 (XI0_I1545_an4 I0_cm93_0 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN5 (XI0_I1545_acon I0_pp14_10 XI0_I1545_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1545_MN2 (XI0_I1545_an1 I0_cm94_0 XI0_I1545_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN1 (VSS I0_cm93_0 XI0_I1545_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN3 (XI0_I1545_an2 I0_cm93_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN4 (VSS I0_cm94_0 XI0_I1545_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1545_MN27 (I0_cm184_2 XI0_I1545_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1545_MN7 (XI0_I1545_an3 I0_cm94_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1545_MN8 (VSS I0_pp14_10 XI0_I1545_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN34 (XI0_I1594_bn3 XI0_I1594_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN35 (VSS I0_fa186_0 XI0_I1594_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN36 (XI0_I1594_bn3 I0_cm232_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN37 (XI0_I1594_bsn XI0_I1594_bcon XI0_I1594_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN40 (XI0_I1594_bn5 I0_cm232_2 XI0_I1594_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN39 (XI0_I1594_bn4 I0_fa186_0 XI0_I1594_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN39_1 (XI0_I1594_bn5 I0_fa186_0 XI0_I1594_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN40_1 (XI0_I1594_bsn I0_cm232_2 XI0_I1594_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1594_MN53 (VSS XI0_I1594_bsn I0_cm233_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1594_MN29 (XI0_I1594_bn1 XI0_I1594_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN30 (XI0_I1594_bcon I0_fa186_0 XI0_I1594_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN33 (XI0_I1594_bn2 I0_cm232_2 XI0_I1594_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN31 (VSS XI0_I1594_s1 XI0_I1594_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN32 (XI0_I1594_bn2 I0_fa186_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1594_MN55 (VSS XI0_I1594_bcon I0_cm233_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1594_MN38 (XI0_I1594_bn4 XI0_I1594_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1594_MN38_1 (VSS XI0_I1594_s1 XI0_I1594_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1594_MN25 (VSS XI0_I1594_asn XI0_I1594_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1594_MN10 (VSS I0_cm183_1 XI0_I1594_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN6 (XI0_I1594_an3 I0_cm183_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN9 (XI0_I1594_asn XI0_I1594_acon XI0_I1594_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN12 (XI0_I1594_an5 I0_cm185_0 XI0_I1594_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN11 (XI0_I1594_an4 I0_cm184_1 XI0_I1594_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1594_MN11_1 (XI0_I1594_an5 I0_cm184_1 XI0_I1594_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1594_MN12_1 (XI0_I1594_asn I0_cm185_0 XI0_I1594_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1594_MN10_1 (XI0_I1594_an4 I0_cm183_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN5 (XI0_I1594_acon I0_cm185_0 XI0_I1594_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1594_MN2 (XI0_I1594_an1 I0_cm184_1 XI0_I1594_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN1 (VSS I0_cm183_1 XI0_I1594_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN3 (XI0_I1594_an2 I0_cm183_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN4 (VSS I0_cm184_1 XI0_I1594_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1594_MN27 (I0_cm233_2 XI0_I1594_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1594_MN7 (XI0_I1594_an3 I0_cm184_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1594_MN8 (VSS I0_cm185_0 XI0_I1594_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN34 (XI0_I1505_bn3 XI0_I1505_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN35 (VSS I0_cm16_0 XI0_I1505_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN36 (XI0_I1505_bn3 I0_cm143_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN37 (XI0_I1505_bsn XI0_I1505_bcon XI0_I1505_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN40 (XI0_I1505_bn5 I0_cm143_2 XI0_I1505_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN39 (XI0_I1505_bn4 I0_cm16_0 XI0_I1505_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN39_1 (XI0_I1505_bn5 I0_cm16_0 XI0_I1505_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN40_1 (XI0_I1505_bsn I0_cm143_2 XI0_I1505_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1505_MN53 (VSS XI0_I1505_bsn I0_cm144_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1505_MN29 (XI0_I1505_bn1 XI0_I1505_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN30 (XI0_I1505_bcon I0_cm16_0 XI0_I1505_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN33 (XI0_I1505_bn2 I0_cm143_2 XI0_I1505_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN31 (VSS XI0_I1505_s1 XI0_I1505_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN32 (XI0_I1505_bn2 I0_cm16_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1505_MN55 (VSS XI0_I1505_bcon I0_cm144_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1505_MN38 (XI0_I1505_bn4 XI0_I1505_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1505_MN38_1 (VSS XI0_I1505_s1 XI0_I1505_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1505_MN25 (VSS XI0_I1505_asn XI0_I1505_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1505_MN10 (VSS I0_cm13_1 XI0_I1505_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN6 (XI0_I1505_an3 I0_cm13_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN9 (XI0_I1505_asn XI0_I1505_acon XI0_I1505_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN12 (XI0_I1505_an5 I0_cm15_0 XI0_I1505_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN11 (XI0_I1505_an4 I0_fa14_1 XI0_I1505_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1505_MN11_1 (XI0_I1505_an5 I0_fa14_1 XI0_I1505_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1505_MN12_1 (XI0_I1505_asn I0_cm15_0 XI0_I1505_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1505_MN10_1 (XI0_I1505_an4 I0_cm13_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN5 (XI0_I1505_acon I0_cm15_0 XI0_I1505_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1505_MN2 (XI0_I1505_an1 I0_fa14_1 XI0_I1505_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN1 (VSS I0_cm13_1 XI0_I1505_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN3 (XI0_I1505_an2 I0_cm13_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN4 (VSS I0_fa14_1 XI0_I1505_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1505_MN27 (I0_cm144_2 XI0_I1505_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1505_MN7 (XI0_I1505_an3 I0_fa14_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1505_MN8 (VSS I0_cm15_0 XI0_I1505_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN34 (XI0_I1504_bn3 XI0_I1504_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN35 (VSS I0_fa14_0 XI0_I1504_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN36 (XI0_I1504_bn3 I0_cm142_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN37 (XI0_I1504_bsn XI0_I1504_bcon XI0_I1504_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN40 (XI0_I1504_bn5 I0_cm142_2 XI0_I1504_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN39 (XI0_I1504_bn4 I0_fa14_0 XI0_I1504_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN39_1 (XI0_I1504_bn5 I0_fa14_0 XI0_I1504_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN40_1 (XI0_I1504_bsn I0_cm142_2 XI0_I1504_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1504_MN53 (VSS XI0_I1504_bsn I0_cm143_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1504_MN29 (XI0_I1504_bn1 XI0_I1504_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN30 (XI0_I1504_bcon I0_fa14_0 XI0_I1504_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN33 (XI0_I1504_bn2 I0_cm142_2 XI0_I1504_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN31 (VSS XI0_I1504_s1 XI0_I1504_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN32 (XI0_I1504_bn2 I0_fa14_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1504_MN55 (VSS XI0_I1504_bcon I0_cm143_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1504_MN38 (XI0_I1504_bn4 XI0_I1504_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1504_MN38_1 (VSS XI0_I1504_s1 XI0_I1504_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1504_MN25 (VSS XI0_I1504_asn XI0_I1504_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1504_MN10 (VSS I0_cm11_1 XI0_I1504_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN6 (XI0_I1504_an3 I0_cm11_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN9 (XI0_I1504_asn XI0_I1504_acon XI0_I1504_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN12 (XI0_I1504_an5 I0_cm13_0 XI0_I1504_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN11 (XI0_I1504_an4 I0_fa12_1 XI0_I1504_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1504_MN11_1 (XI0_I1504_an5 I0_fa12_1 XI0_I1504_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1504_MN12_1 (XI0_I1504_asn I0_cm13_0 XI0_I1504_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1504_MN10_1 (XI0_I1504_an4 I0_cm11_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN5 (XI0_I1504_acon I0_cm13_0 XI0_I1504_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1504_MN2 (XI0_I1504_an1 I0_fa12_1 XI0_I1504_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN1 (VSS I0_cm11_1 XI0_I1504_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN3 (XI0_I1504_an2 I0_cm11_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN4 (VSS I0_fa12_1 XI0_I1504_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1504_MN27 (I0_cm143_2 XI0_I1504_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1504_MN7 (XI0_I1504_an3 I0_fa12_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1504_MN8 (VSS I0_cm13_0 XI0_I1504_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN34 (XI0_I1507_bn3 XI0_I1507_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN35 (VSS I0_cm20_0 XI0_I1507_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN36 (XI0_I1507_bn3 I0_cm145_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN37 (XI0_I1507_bsn XI0_I1507_bcon XI0_I1507_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN40 (XI0_I1507_bn5 I0_cm145_2 XI0_I1507_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN39 (XI0_I1507_bn4 I0_cm20_0 XI0_I1507_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN39_1 (XI0_I1507_bn5 I0_cm20_0 XI0_I1507_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN40_1 (XI0_I1507_bsn I0_cm145_2 XI0_I1507_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1507_MN53 (VSS XI0_I1507_bsn I0_cm146_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1507_MN29 (XI0_I1507_bn1 XI0_I1507_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN30 (XI0_I1507_bcon I0_cm20_0 XI0_I1507_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN33 (XI0_I1507_bn2 I0_cm145_2 XI0_I1507_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN31 (VSS XI0_I1507_s1 XI0_I1507_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN32 (XI0_I1507_bn2 I0_cm20_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1507_MN55 (VSS XI0_I1507_bcon I0_cm146_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1507_MN38 (XI0_I1507_bn4 XI0_I1507_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1507_MN38_1 (VSS XI0_I1507_s1 XI0_I1507_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1507_MN25 (VSS XI0_I1507_asn XI0_I1507_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1507_MN10 (VSS I0_cm17_1 XI0_I1507_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN6 (XI0_I1507_an3 I0_cm17_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN9 (XI0_I1507_asn XI0_I1507_acon XI0_I1507_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN12 (XI0_I1507_an5 I0_cm19_0 XI0_I1507_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN11 (XI0_I1507_an4 I0_cm18_1 XI0_I1507_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1507_MN11_1 (XI0_I1507_an5 I0_cm18_1 XI0_I1507_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1507_MN12_1 (XI0_I1507_asn I0_cm19_0 XI0_I1507_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1507_MN10_1 (XI0_I1507_an4 I0_cm17_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN5 (XI0_I1507_acon I0_cm19_0 XI0_I1507_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1507_MN2 (XI0_I1507_an1 I0_cm18_1 XI0_I1507_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN1 (VSS I0_cm17_1 XI0_I1507_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN3 (XI0_I1507_an2 I0_cm17_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN4 (VSS I0_cm18_1 XI0_I1507_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1507_MN27 (I0_cm146_2 XI0_I1507_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1507_MN7 (XI0_I1507_an3 I0_cm18_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1507_MN8 (VSS I0_cm19_0 XI0_I1507_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN34 (XI0_I1575_bn3 XI0_I1575_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN35 (VSS I0_fa30_0 XI0_I1575_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN36 (XI0_I1575_bn3 I0_B_21_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN37 (XI0_I1575_bsn XI0_I1575_bcon XI0_I1575_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN40 (XI0_I1575_bn5 I0_B_21_b3_5 XI0_I1575_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN39 (XI0_I1575_bn4 I0_fa30_0 XI0_I1575_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN39_1 (XI0_I1575_bn5 I0_fa30_0 XI0_I1575_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN40_1 (XI0_I1575_bsn I0_B_21_b3_5 XI0_I1575_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1575_MN53 (VSS XI0_I1575_bsn I0_cm214_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1575_MN29 (XI0_I1575_bn1 XI0_I1575_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN30 (XI0_I1575_bcon I0_fa30_0 XI0_I1575_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN33 (XI0_I1575_bn2 I0_B_21_b3_5 XI0_I1575_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN31 (VSS XI0_I1575_s1 XI0_I1575_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN32 (XI0_I1575_bn2 I0_fa30_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1575_MN55 (VSS XI0_I1575_bcon I0_cm214_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1575_MN38 (XI0_I1575_bn4 XI0_I1575_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1575_MN38_1 (VSS XI0_I1575_s1 XI0_I1575_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1575_MN25 (VSS XI0_I1575_asn XI0_I1575_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1575_MN10 (VSS I0_cm149_1 XI0_I1575_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN6 (XI0_I1575_an3 I0_cm149_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN9 (XI0_I1575_asn XI0_I1575_acon XI0_I1575_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN12 (XI0_I1575_an5 I0_cm151_0 XI0_I1575_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN11 (XI0_I1575_an4 I0_fa150_1 XI0_I1575_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1575_MN11_1 (XI0_I1575_an5 I0_fa150_1 XI0_I1575_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1575_MN12_1 (XI0_I1575_asn I0_cm151_0 XI0_I1575_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1575_MN10_1 (XI0_I1575_an4 I0_cm149_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN5 (XI0_I1575_acon I0_cm151_0 XI0_I1575_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1575_MN2 (XI0_I1575_an1 I0_fa150_1 XI0_I1575_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN1 (VSS I0_cm149_1 XI0_I1575_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN3 (XI0_I1575_an2 I0_cm149_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN4 (VSS I0_fa150_1 XI0_I1575_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1575_MN27 (I0_cm214_2 XI0_I1575_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1575_MN7 (XI0_I1575_an3 I0_fa150_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1575_MN8 (VSS I0_cm151_0 XI0_I1575_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN34 (XI0_I1508_bn3 XI0_I1508_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN35 (VSS I0_cm22_0 XI0_I1508_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN36 (XI0_I1508_bn3 I0_cm146_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN37 (XI0_I1508_bsn XI0_I1508_bcon XI0_I1508_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN40 (XI0_I1508_bn5 I0_cm146_2 XI0_I1508_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN39 (XI0_I1508_bn4 I0_cm22_0 XI0_I1508_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN39_1 (XI0_I1508_bn5 I0_cm22_0 XI0_I1508_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN40_1 (XI0_I1508_bsn I0_cm146_2 XI0_I1508_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1508_MN53 (VSS XI0_I1508_bsn I0_cm147_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1508_MN29 (XI0_I1508_bn1 XI0_I1508_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN30 (XI0_I1508_bcon I0_cm22_0 XI0_I1508_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN33 (XI0_I1508_bn2 I0_cm146_2 XI0_I1508_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN31 (VSS XI0_I1508_s1 XI0_I1508_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN32 (XI0_I1508_bn2 I0_cm22_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1508_MN55 (VSS XI0_I1508_bcon I0_cm147_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1508_MN38 (XI0_I1508_bn4 XI0_I1508_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1508_MN38_1 (VSS XI0_I1508_s1 XI0_I1508_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1508_MN25 (VSS XI0_I1508_asn XI0_I1508_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1508_MN10 (VSS I0_cm19_1 XI0_I1508_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN6 (XI0_I1508_an3 I0_cm19_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN9 (XI0_I1508_asn XI0_I1508_acon XI0_I1508_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN12 (XI0_I1508_an5 I0_cm21_0 XI0_I1508_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN11 (XI0_I1508_an4 I0_cm20_1 XI0_I1508_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1508_MN11_1 (XI0_I1508_an5 I0_cm20_1 XI0_I1508_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1508_MN12_1 (XI0_I1508_asn I0_cm21_0 XI0_I1508_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1508_MN10_1 (XI0_I1508_an4 I0_cm19_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN5 (XI0_I1508_acon I0_cm21_0 XI0_I1508_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1508_MN2 (XI0_I1508_an1 I0_cm20_1 XI0_I1508_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN1 (VSS I0_cm19_1 XI0_I1508_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN3 (XI0_I1508_an2 I0_cm19_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN4 (VSS I0_cm20_1 XI0_I1508_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1508_MN27 (I0_cm147_2 XI0_I1508_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1508_MN7 (XI0_I1508_an3 I0_cm20_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1508_MN8 (VSS I0_cm21_0 XI0_I1508_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN34 (XI0_I1403_bn3 XI0_I1403_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN35 (VSS I0_pp11_2 XI0_I1403_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN36 (XI0_I1403_bn3 I0_cm39_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN37 (XI0_I1403_bsn XI0_I1403_bcon XI0_I1403_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN40 (XI0_I1403_bn5 I0_cm39_2 XI0_I1403_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN39 (XI0_I1403_bn4 I0_pp11_2 XI0_I1403_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN39_1 (XI0_I1403_bn5 I0_pp11_2 XI0_I1403_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN40_1 (XI0_I1403_bsn I0_cm39_2 XI0_I1403_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1403_MN53 (VSS XI0_I1403_bsn I0_cm42_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1403_MN29 (XI0_I1403_bn1 XI0_I1403_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN30 (XI0_I1403_bcon I0_pp11_2 XI0_I1403_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN33 (XI0_I1403_bn2 I0_cm39_2 XI0_I1403_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN31 (VSS XI0_I1403_s1 XI0_I1403_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN32 (XI0_I1403_bn2 I0_pp11_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1403_MN55 (VSS XI0_I1403_bcon I0_cm42_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1403_MN38 (XI0_I1403_bn4 XI0_I1403_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1403_MN38_1 (VSS XI0_I1403_s1 XI0_I1403_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1403_MN25 (VSS XI0_I1403_asn XI0_I1403_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1403_MN10 (VSS I0_pp8_8 XI0_I1403_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN6 (XI0_I1403_an3 I0_pp8_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN9 (XI0_I1403_asn XI0_I1403_acon XI0_I1403_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN12 (XI0_I1403_an5 I0_pp10_4 XI0_I1403_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN11 (XI0_I1403_an4 I0_pp9_6 XI0_I1403_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1403_MN11_1 (XI0_I1403_an5 I0_pp9_6 XI0_I1403_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1403_MN12_1 (XI0_I1403_asn I0_pp10_4 XI0_I1403_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1403_MN10_1 (XI0_I1403_an4 I0_pp8_8 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN5 (XI0_I1403_acon I0_pp10_4 XI0_I1403_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1403_MN2 (XI0_I1403_an1 I0_pp9_6 XI0_I1403_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN1 (VSS I0_pp8_8 XI0_I1403_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN3 (XI0_I1403_an2 I0_pp8_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN4 (VSS I0_pp9_6 XI0_I1403_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1403_MN27 (I0_cm42_2 XI0_I1403_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1403_MN7 (XI0_I1403_an3 I0_pp9_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1403_MN8 (VSS I0_pp10_4 XI0_I1403_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN34 (XI0_I1441_bn3 XI0_I1441_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN35 (VSS I0_pp15_4 XI0_I1441_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN36 (XI0_I1441_bn3 I0_cm76_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN37 (XI0_I1441_bsn XI0_I1441_bcon XI0_I1441_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN40 (XI0_I1441_bn5 I0_cm76_2 XI0_I1441_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN39 (XI0_I1441_bn4 I0_pp15_4 XI0_I1441_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN39_1 (XI0_I1441_bn5 I0_pp15_4 XI0_I1441_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN40_1 (XI0_I1441_bsn I0_cm76_2 XI0_I1441_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1441_MN53 (VSS XI0_I1441_bsn I0_cm80_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1441_MN29 (XI0_I1441_bn1 XI0_I1441_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN30 (XI0_I1441_bcon I0_pp15_4 XI0_I1441_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN33 (XI0_I1441_bn2 I0_cm76_2 XI0_I1441_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN31 (VSS XI0_I1441_s1 XI0_I1441_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN32 (XI0_I1441_bn2 I0_pp15_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1441_MN55 (VSS XI0_I1441_bcon I0_cm80_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1441_MN38 (XI0_I1441_bn4 XI0_I1441_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1441_MN38_1 (VSS XI0_I1441_s1 XI0_I1441_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1441_MN25 (VSS XI0_I1441_asn XI0_I1441_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1441_MN10 (VSS I0_pp12_10 XI0_I1441_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN6 (XI0_I1441_an3 I0_pp12_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN9 (XI0_I1441_asn XI0_I1441_acon XI0_I1441_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN12 (XI0_I1441_an5 I0_pp14_6 XI0_I1441_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN11 (XI0_I1441_an4 I0_pp13_8 XI0_I1441_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1441_MN11_1 (XI0_I1441_an5 I0_pp13_8 XI0_I1441_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1441_MN12_1 (XI0_I1441_asn I0_pp14_6 XI0_I1441_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1441_MN10_1 (XI0_I1441_an4 I0_pp12_10 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN5 (XI0_I1441_acon I0_pp14_6 XI0_I1441_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1441_MN2 (XI0_I1441_an1 I0_pp13_8 XI0_I1441_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN1 (VSS I0_pp12_10 XI0_I1441_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN3 (XI0_I1441_an2 I0_pp12_10 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN4 (VSS I0_pp13_8 XI0_I1441_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1441_MN27 (I0_cm80_2 XI0_I1441_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1441_MN7 (XI0_I1441_an3 I0_pp13_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1441_MN8 (VSS I0_pp14_6 XI0_I1441_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN34 (XI0_I1452_bn3 XI0_I1452_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN35 (VSS I0_pp13_11 XI0_I1452_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN36 (XI0_I1452_bn3 I0_cm87_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN37 (XI0_I1452_bsn XI0_I1452_bcon XI0_I1452_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN40 (XI0_I1452_bn5 I0_cm87_2 XI0_I1452_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN39 (XI0_I1452_bn4 I0_pp13_11 XI0_I1452_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN39_1 (XI0_I1452_bn5 I0_pp13_11 XI0_I1452_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN40_1 (XI0_I1452_bsn I0_cm87_2 XI0_I1452_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1452_MN53 (VSS XI0_I1452_bsn I0_cm91_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1452_MN29 (XI0_I1452_bn1 XI0_I1452_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN30 (XI0_I1452_bcon I0_pp13_11 XI0_I1452_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN33 (XI0_I1452_bn2 I0_cm87_2 XI0_I1452_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN31 (VSS XI0_I1452_s1 XI0_I1452_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN32 (XI0_I1452_bn2 I0_pp13_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1452_MN55 (VSS XI0_I1452_bcon I0_cm91_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1452_MN38 (XI0_I1452_bn4 XI0_I1452_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1452_MN38_1 (VSS XI0_I1452_s1 XI0_I1452_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1452_MN25 (VSS XI0_I1452_asn XI0_I1452_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1452_MN10 (VSS I0_pp10_17 XI0_I1452_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN6 (XI0_I1452_an3 I0_pp10_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN9 (XI0_I1452_asn XI0_I1452_acon XI0_I1452_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN12 (XI0_I1452_an5 I0_pp12_13 XI0_I1452_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN11 (XI0_I1452_an4 I0_pp11_15 XI0_I1452_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1452_MN11_1 (XI0_I1452_an5 I0_pp11_15 XI0_I1452_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1452_MN12_1 (XI0_I1452_asn I0_pp12_13 XI0_I1452_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1452_MN10_1 (XI0_I1452_an4 I0_pp10_17 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN5 (XI0_I1452_acon I0_pp12_13 XI0_I1452_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1452_MN2 (XI0_I1452_an1 I0_pp11_15 XI0_I1452_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN1 (VSS I0_pp10_17 XI0_I1452_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN3 (XI0_I1452_an2 I0_pp10_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN4 (VSS I0_pp11_15 XI0_I1452_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1452_MN27 (I0_cm91_2 XI0_I1452_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1452_MN7 (XI0_I1452_an3 I0_pp11_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1452_MN8 (VSS I0_pp12_13 XI0_I1452_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN34 (XI0_I1506_bn3 XI0_I1506_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN35 (VSS I0_cm18_0 XI0_I1506_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN36 (XI0_I1506_bn3 I0_cm144_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN37 (XI0_I1506_bsn XI0_I1506_bcon XI0_I1506_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN40 (XI0_I1506_bn5 I0_cm144_2 XI0_I1506_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN39 (XI0_I1506_bn4 I0_cm18_0 XI0_I1506_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN39_1 (XI0_I1506_bn5 I0_cm18_0 XI0_I1506_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN40_1 (XI0_I1506_bsn I0_cm144_2 XI0_I1506_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1506_MN53 (VSS XI0_I1506_bsn I0_cm145_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1506_MN29 (XI0_I1506_bn1 XI0_I1506_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN30 (XI0_I1506_bcon I0_cm18_0 XI0_I1506_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN33 (XI0_I1506_bn2 I0_cm144_2 XI0_I1506_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN31 (VSS XI0_I1506_s1 XI0_I1506_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN32 (XI0_I1506_bn2 I0_cm18_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1506_MN55 (VSS XI0_I1506_bcon I0_cm145_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1506_MN38 (XI0_I1506_bn4 XI0_I1506_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1506_MN38_1 (VSS XI0_I1506_s1 XI0_I1506_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1506_MN25 (VSS XI0_I1506_asn XI0_I1506_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1506_MN10 (VSS I0_cm15_1 XI0_I1506_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN6 (XI0_I1506_an3 I0_cm15_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN9 (XI0_I1506_asn XI0_I1506_acon XI0_I1506_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN12 (XI0_I1506_an5 I0_cm17_0 XI0_I1506_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN11 (XI0_I1506_an4 I0_cm16_1 XI0_I1506_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1506_MN11_1 (XI0_I1506_an5 I0_cm16_1 XI0_I1506_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1506_MN12_1 (XI0_I1506_asn I0_cm17_0 XI0_I1506_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1506_MN10_1 (XI0_I1506_an4 I0_cm15_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN5 (XI0_I1506_acon I0_cm17_0 XI0_I1506_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1506_MN2 (XI0_I1506_an1 I0_cm16_1 XI0_I1506_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN1 (VSS I0_cm15_1 XI0_I1506_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN3 (XI0_I1506_an2 I0_cm15_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN4 (VSS I0_cm16_1 XI0_I1506_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1506_MN27 (I0_cm145_2 XI0_I1506_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1506_MN7 (XI0_I1506_an3 I0_cm16_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1506_MN8 (VSS I0_cm17_0 XI0_I1506_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN34 (XI0_I1400_bn3 XI0_I1400_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN35 (VSS I0_pp11_1 XI0_I1400_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN36 (XI0_I1400_bn3 I0_cm36_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN37 (XI0_I1400_bsn XI0_I1400_bcon XI0_I1400_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN40 (XI0_I1400_bn5 I0_cm36_2 XI0_I1400_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN39 (XI0_I1400_bn4 I0_pp11_1 XI0_I1400_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN39_1 (XI0_I1400_bn5 I0_pp11_1 XI0_I1400_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN40_1 (XI0_I1400_bsn I0_cm36_2 XI0_I1400_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1400_MN53 (VSS XI0_I1400_bsn I0_cm39_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1400_MN29 (XI0_I1400_bn1 XI0_I1400_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN30 (XI0_I1400_bcon I0_pp11_1 XI0_I1400_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN33 (XI0_I1400_bn2 I0_cm36_2 XI0_I1400_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN31 (VSS XI0_I1400_s1 XI0_I1400_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN32 (XI0_I1400_bn2 I0_pp11_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1400_MN55 (VSS XI0_I1400_bcon I0_cm39_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1400_MN38 (XI0_I1400_bn4 XI0_I1400_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1400_MN38_1 (VSS XI0_I1400_s1 XI0_I1400_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1400_MN25 (VSS XI0_I1400_asn XI0_I1400_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1400_MN10 (VSS I0_pp8_7 XI0_I1400_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN6 (XI0_I1400_an3 I0_pp8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN9 (XI0_I1400_asn XI0_I1400_acon XI0_I1400_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN12 (XI0_I1400_an5 I0_pp10_3 XI0_I1400_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN11 (XI0_I1400_an4 I0_pp9_5 XI0_I1400_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1400_MN11_1 (XI0_I1400_an5 I0_pp9_5 XI0_I1400_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1400_MN12_1 (XI0_I1400_asn I0_pp10_3 XI0_I1400_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1400_MN10_1 (XI0_I1400_an4 I0_pp8_7 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN5 (XI0_I1400_acon I0_pp10_3 XI0_I1400_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1400_MN2 (XI0_I1400_an1 I0_pp9_5 XI0_I1400_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN1 (VSS I0_pp8_7 XI0_I1400_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN3 (XI0_I1400_an2 I0_pp8_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN4 (VSS I0_pp9_5 XI0_I1400_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1400_MN27 (I0_cm39_2 XI0_I1400_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1400_MN7 (XI0_I1400_an3 I0_pp9_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1400_MN8 (VSS I0_pp10_3 XI0_I1400_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN34 (XI0_I1455_bn3 XI0_I1455_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN35 (VSS I0_pp13_12 XI0_I1455_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN36 (XI0_I1455_bn3 I0_cm91_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN37 (XI0_I1455_bsn XI0_I1455_bcon XI0_I1455_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN40 (XI0_I1455_bn5 I0_cm91_2 XI0_I1455_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN39 (XI0_I1455_bn4 I0_pp13_12 XI0_I1455_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN39_1 (XI0_I1455_bn5 I0_pp13_12 XI0_I1455_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN40_1 (XI0_I1455_bsn I0_cm91_2 XI0_I1455_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1455_MN53 (VSS XI0_I1455_bsn I0_cm94_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1455_MN29 (XI0_I1455_bn1 XI0_I1455_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN30 (XI0_I1455_bcon I0_pp13_12 XI0_I1455_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN33 (XI0_I1455_bn2 I0_cm91_2 XI0_I1455_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN31 (VSS XI0_I1455_s1 XI0_I1455_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN32 (XI0_I1455_bn2 I0_pp13_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1455_MN55 (VSS XI0_I1455_bcon I0_cm94_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1455_MN38 (XI0_I1455_bn4 XI0_I1455_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1455_MN38_1 (VSS XI0_I1455_s1 XI0_I1455_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1455_MN25 (VSS XI0_I1455_asn XI0_I1455_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1455_MN10 (VSS I0_pp10_18 XI0_I1455_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN6 (XI0_I1455_an3 I0_pp10_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN9 (XI0_I1455_asn XI0_I1455_acon XI0_I1455_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN12 (XI0_I1455_an5 I0_pp12_14 XI0_I1455_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN11 (XI0_I1455_an4 I0_pp11_16 XI0_I1455_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1455_MN11_1 (XI0_I1455_an5 I0_pp11_16 XI0_I1455_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1455_MN12_1 (XI0_I1455_asn I0_pp12_14 XI0_I1455_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1455_MN10_1 (XI0_I1455_an4 I0_pp10_18 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN5 (XI0_I1455_acon I0_pp12_14 XI0_I1455_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1455_MN2 (XI0_I1455_an1 I0_pp11_16 XI0_I1455_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN1 (VSS I0_pp10_18 XI0_I1455_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN3 (XI0_I1455_an2 I0_pp10_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN4 (VSS I0_pp11_16 XI0_I1455_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1455_MN27 (I0_cm94_2 XI0_I1455_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1455_MN7 (XI0_I1455_an3 I0_pp11_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1455_MN8 (VSS I0_pp12_14 XI0_I1455_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN34 (XI0_I1457_bn3 XI0_I1457_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN35 (VSS I0_pp10_19 XI0_I1457_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN36 (XI0_I1457_bn3 I0_cm93_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN37 (XI0_I1457_bsn XI0_I1457_bcon XI0_I1457_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN40 (XI0_I1457_bn5 I0_cm93_2 XI0_I1457_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN39 (XI0_I1457_bn4 I0_pp10_19 XI0_I1457_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN39_1 (XI0_I1457_bn5 I0_pp10_19 XI0_I1457_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN40_1 (XI0_I1457_bsn I0_cm93_2 XI0_I1457_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1457_MN53 (VSS XI0_I1457_bsn I0_cm96_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1457_MN29 (XI0_I1457_bn1 XI0_I1457_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN30 (XI0_I1457_bcon I0_pp10_19 XI0_I1457_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN33 (XI0_I1457_bn2 I0_cm93_2 XI0_I1457_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN31 (VSS XI0_I1457_s1 XI0_I1457_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN32 (XI0_I1457_bn2 I0_pp10_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1457_MN55 (VSS XI0_I1457_bcon I0_cm96_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1457_MN38 (XI0_I1457_bn4 XI0_I1457_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1457_MN38_1 (VSS XI0_I1457_s1 XI0_I1457_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1457_MN25 (VSS XI0_I1457_asn XI0_I1457_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1457_MN10 (VSS I0_pp7_25 XI0_I1457_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN6 (XI0_I1457_an3 I0_pp7_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN9 (XI0_I1457_asn XI0_I1457_acon XI0_I1457_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN12 (XI0_I1457_an5 I0_pp9_21 XI0_I1457_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN11 (XI0_I1457_an4 I0_pp8_23 XI0_I1457_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1457_MN11_1 (XI0_I1457_an5 I0_pp8_23 XI0_I1457_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1457_MN12_1 (XI0_I1457_asn I0_pp9_21 XI0_I1457_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1457_MN10_1 (XI0_I1457_an4 I0_pp7_25 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN5 (XI0_I1457_acon I0_pp9_21 XI0_I1457_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1457_MN2 (XI0_I1457_an1 I0_pp8_23 XI0_I1457_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN1 (VSS I0_pp7_25 XI0_I1457_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN3 (XI0_I1457_an2 I0_pp7_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN4 (VSS I0_pp8_23 XI0_I1457_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1457_MN27 (I0_cm96_2 XI0_I1457_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1457_MN7 (XI0_I1457_an3 I0_pp8_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1457_MN8 (VSS I0_pp9_21 XI0_I1457_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN34 (XI0_I1397_bn3 XI0_I1397_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN35 (VSS I0_pp11_0 XI0_I1397_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN36 (XI0_I1397_bn3 I0_B_23_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN37 (XI0_I1397_bsn XI0_I1397_bcon XI0_I1397_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN40 (XI0_I1397_bn5 I0_B_23_b3_5 XI0_I1397_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN39 (XI0_I1397_bn4 I0_pp11_0 XI0_I1397_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN39_1 (XI0_I1397_bn5 I0_pp11_0 XI0_I1397_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN40_1 (XI0_I1397_bsn I0_B_23_b3_5 XI0_I1397_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1397_MN53 (VSS XI0_I1397_bsn I0_cm36_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1397_MN29 (XI0_I1397_bn1 XI0_I1397_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN30 (XI0_I1397_bcon I0_pp11_0 XI0_I1397_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN33 (XI0_I1397_bn2 I0_B_23_b3_5 XI0_I1397_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN31 (VSS XI0_I1397_s1 XI0_I1397_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN32 (XI0_I1397_bn2 I0_pp11_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1397_MN55 (VSS XI0_I1397_bcon I0_cm36_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1397_MN38 (XI0_I1397_bn4 XI0_I1397_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1397_MN38_1 (VSS XI0_I1397_s1 XI0_I1397_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1397_MN25 (VSS XI0_I1397_asn XI0_I1397_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1397_MN10 (VSS I0_pp8_6 XI0_I1397_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN6 (XI0_I1397_an3 I0_pp8_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN9 (XI0_I1397_asn XI0_I1397_acon XI0_I1397_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN12 (XI0_I1397_an5 I0_pp10_2 XI0_I1397_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN11 (XI0_I1397_an4 I0_pp9_4 XI0_I1397_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1397_MN11_1 (XI0_I1397_an5 I0_pp9_4 XI0_I1397_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1397_MN12_1 (XI0_I1397_asn I0_pp10_2 XI0_I1397_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1397_MN10_1 (XI0_I1397_an4 I0_pp8_6 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN5 (XI0_I1397_acon I0_pp10_2 XI0_I1397_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1397_MN2 (XI0_I1397_an1 I0_pp9_4 XI0_I1397_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN1 (VSS I0_pp8_6 XI0_I1397_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN3 (XI0_I1397_an2 I0_pp8_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN4 (VSS I0_pp9_4 XI0_I1397_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1397_MN27 (I0_cm36_2 XI0_I1397_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1397_MN7 (XI0_I1397_an3 I0_pp9_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1397_MN8 (VSS I0_pp10_2 XI0_I1397_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN34 (XI0_I1437_bn3 XI0_I1437_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN35 (VSS I0_pp15_3 XI0_I1437_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN36 (XI0_I1437_bn3 I0_cm72_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN37 (XI0_I1437_bsn XI0_I1437_bcon XI0_I1437_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN40 (XI0_I1437_bn5 I0_cm72_2 XI0_I1437_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN39 (XI0_I1437_bn4 I0_pp15_3 XI0_I1437_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN39_1 (XI0_I1437_bn5 I0_pp15_3 XI0_I1437_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN40_1 (XI0_I1437_bsn I0_cm72_2 XI0_I1437_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1437_MN53 (VSS XI0_I1437_bsn I0_cm76_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1437_MN29 (XI0_I1437_bn1 XI0_I1437_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN30 (XI0_I1437_bcon I0_pp15_3 XI0_I1437_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN33 (XI0_I1437_bn2 I0_cm72_2 XI0_I1437_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN31 (VSS XI0_I1437_s1 XI0_I1437_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN32 (XI0_I1437_bn2 I0_pp15_3 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1437_MN55 (VSS XI0_I1437_bcon I0_cm76_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1437_MN38 (XI0_I1437_bn4 XI0_I1437_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1437_MN38_1 (VSS XI0_I1437_s1 XI0_I1437_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1437_MN25 (VSS XI0_I1437_asn XI0_I1437_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1437_MN10 (VSS I0_pp12_9 XI0_I1437_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN6 (XI0_I1437_an3 I0_pp12_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN9 (XI0_I1437_asn XI0_I1437_acon XI0_I1437_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN12 (XI0_I1437_an5 I0_pp14_5 XI0_I1437_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN11 (XI0_I1437_an4 I0_pp13_7 XI0_I1437_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1437_MN11_1 (XI0_I1437_an5 I0_pp13_7 XI0_I1437_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1437_MN12_1 (XI0_I1437_asn I0_pp14_5 XI0_I1437_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1437_MN10_1 (XI0_I1437_an4 I0_pp12_9 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN5 (XI0_I1437_acon I0_pp14_5 XI0_I1437_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1437_MN2 (XI0_I1437_an1 I0_pp13_7 XI0_I1437_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN1 (VSS I0_pp12_9 XI0_I1437_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN3 (XI0_I1437_an2 I0_pp12_9 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN4 (VSS I0_pp13_7 XI0_I1437_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1437_MN27 (I0_cm76_2 XI0_I1437_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1437_MN7 (XI0_I1437_an3 I0_pp13_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1437_MN8 (VSS I0_pp14_5 XI0_I1437_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN34 (XI0_I1458_bn3 XI0_I1458_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN35 (VSS I0_pp14_11 XI0_I1458_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN36 (XI0_I1458_bn3 I0_cm94_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN37 (XI0_I1458_bsn XI0_I1458_bcon XI0_I1458_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN40 (XI0_I1458_bn5 I0_cm94_2 XI0_I1458_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN39 (XI0_I1458_bn4 I0_pp14_11 XI0_I1458_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN39_1 (XI0_I1458_bn5 I0_pp14_11 XI0_I1458_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN40_1 (XI0_I1458_bsn I0_cm94_2 XI0_I1458_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1458_MN53 (VSS XI0_I1458_bsn I0_cm97_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1458_MN29 (XI0_I1458_bn1 XI0_I1458_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN30 (XI0_I1458_bcon I0_pp14_11 XI0_I1458_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN33 (XI0_I1458_bn2 I0_cm94_2 XI0_I1458_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN31 (VSS XI0_I1458_s1 XI0_I1458_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN32 (XI0_I1458_bn2 I0_pp14_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1458_MN55 (VSS XI0_I1458_bcon I0_cm97_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1458_MN38 (XI0_I1458_bn4 XI0_I1458_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21998u ps=0.67998u
    I_MXI0_I1458_MN38_1 (VSS XI0_I1458_s1 XI0_I1458_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67998u ps=1.21998u
    I_MXI0_I1458_MN25 (VSS XI0_I1458_asn XI0_I1458_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1458_MN10 (VSS I0_pp11_17 XI0_I1458_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN6 (XI0_I1458_an3 I0_pp11_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN9 (XI0_I1458_asn XI0_I1458_acon XI0_I1458_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN12 (XI0_I1458_an5 I0_pp13_13 XI0_I1458_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN11 (XI0_I1458_an4 I0_pp12_15 XI0_I1458_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75998u ps=0.67998u
    I_MXI0_I1458_MN11_1 (XI0_I1458_an5 I0_pp12_15 XI0_I1458_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67998u ps=1.75998u
    I_MXI0_I1458_MN12_1 (XI0_I1458_asn I0_pp13_13 XI0_I1458_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1458_MN10_1 (XI0_I1458_an4 I0_pp11_17 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN5 (XI0_I1458_acon I0_pp13_13 XI0_I1458_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1458_MN2 (XI0_I1458_an1 I0_pp12_15 XI0_I1458_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN1 (VSS I0_pp11_17 XI0_I1458_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN3 (XI0_I1458_an2 I0_pp11_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN4 (VSS I0_pp12_15 XI0_I1458_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1458_MN27 (I0_cm97_2 XI0_I1458_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1458_MN7 (XI0_I1458_an3 I0_pp12_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67998u ps=1.15998u
    I_MXI0_I1458_MN8 (VSS I0_pp13_13 XI0_I1458_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1460_MN34 (XI0_I1460_bn3 XI0_I1460_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1460_MN35 (VSS I0_pp10_20 XI0_I1460_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1460_MN36 (XI0_I1460_bn3 I0_cm96_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1460_MN37 (XI0_I1460_bsn XI0_I1460_bcon XI0_I1460_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1460_MN40 (XI0_I1460_bn5 I0_cm96_2 XI0_I1460_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67998u ps=0.67998u
    I_MXI0_I1460_MN39 (XI0_I1460_bn4 I0_pp10_20 XI0_I1460_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1460_MN39_1 (XI0_I1460_bn5 I0_pp10_20 XI0_I1460_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1460_MN40_1 (XI0_I1460_bsn I0_cm96_2 XI0_I1460_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15998u ps=0.67998u
    I_MXI0_I1460_MN53 (VSS XI0_I1460_bsn I0_cm99_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15998u ps=1.15998u
    I_MXI0_I1460_MN29 (XI0_I1460_bn1 XI0_I1460_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67998u ps=0.67998u
    I_MXI0_I1460_MN30 (XI0_I1460_bcon I0_pp10_20 XI0_I1460_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1460_MN33 (XI0_I1460_bn2 I0_cm96_2 XI0_I1460_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1460_MN31 (VSS XI0_I1460_s1 XI0_I1460_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67998u ps=0.67998u
    I_MXI0_I1460_MN32 (XI0_I1460_bn2 I0_pp10_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15998u ps=0.67998u
    I_MXI0_I1460_MN55 (VSS XI0_I1460_bcon I0_cm99_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67998u ps=1.15998u
    I_MXI0_I1460_MN38 (XI0_I1460_bn4 XI0_I1460_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1460_MN38_1 (VSS XI0_I1460_s1 XI0_I1460_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1460_MN25 (VSS XI0_I1460_asn XI0_I1460_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1460_MN10 (VSS I0_pp7_26 XI0_I1460_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1460_MN6 (XI0_I1460_an3 I0_pp7_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1460_MN9 (XI0_I1460_asn XI0_I1460_acon XI0_I1460_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1460_MN12 (XI0_I1460_an5 I0_pp9_22 XI0_I1460_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1460_MN11 (XI0_I1460_an4 I0_pp8_24 XI0_I1460_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1460_MN11_1 (XI0_I1460_an5 I0_pp8_24 XI0_I1460_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1460_MN12_1 (XI0_I1460_asn I0_pp9_22 XI0_I1460_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1460_MN10_1 (XI0_I1460_an4 I0_pp7_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1460_MN5 (XI0_I1460_acon I0_pp9_22 XI0_I1460_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1460_MN2 (XI0_I1460_an1 I0_pp8_24 XI0_I1460_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1460_MN1 (VSS I0_pp7_26 XI0_I1460_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1460_MN3 (XI0_I1460_an2 I0_pp7_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1460_MN4 (VSS I0_pp8_24 XI0_I1460_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1460_MN27 (I0_cm99_2 XI0_I1460_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1460_MN7 (XI0_I1460_an3 I0_pp8_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1460_MN8 (VSS I0_pp9_22 XI0_I1460_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN34 (XI0_I1548_bn3 XI0_I1548_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN35 (VSS I0_cm98_0 XI0_I1548_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN36 (XI0_I1548_bn3 I0_cm185_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN37 (XI0_I1548_bsn XI0_I1548_bcon XI0_I1548_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN40 (XI0_I1548_bn5 I0_cm185_2 XI0_I1548_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN39 (XI0_I1548_bn4 I0_cm98_0 XI0_I1548_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN39_1 (XI0_I1548_bn5 I0_cm98_0 XI0_I1548_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN40_1 (XI0_I1548_bsn I0_cm185_2 XI0_I1548_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1548_MN53 (VSS XI0_I1548_bsn I0_cm187_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1548_MN29 (XI0_I1548_bn1 XI0_I1548_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN30 (XI0_I1548_bcon I0_cm98_0 XI0_I1548_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN33 (XI0_I1548_bn2 I0_cm185_2 XI0_I1548_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN31 (VSS XI0_I1548_s1 XI0_I1548_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN32 (XI0_I1548_bn2 I0_cm98_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1548_MN55 (VSS XI0_I1548_bcon I0_cm187_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1548_MN38 (XI0_I1548_bn4 XI0_I1548_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1548_MN38_1 (VSS XI0_I1548_s1 XI0_I1548_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1548_MN25 (VSS XI0_I1548_asn XI0_I1548_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1548_MN10 (VSS I0_cm95_1 XI0_I1548_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN6 (XI0_I1548_an3 I0_cm95_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN9 (XI0_I1548_asn XI0_I1548_acon XI0_I1548_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN12 (XI0_I1548_an5 I0_cm97_1 XI0_I1548_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN11 (XI0_I1548_an4 I0_cm96_1 XI0_I1548_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1548_MN11_1 (XI0_I1548_an5 I0_cm96_1 XI0_I1548_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1548_MN12_1 (XI0_I1548_asn I0_cm97_1 XI0_I1548_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1548_MN10_1 (XI0_I1548_an4 I0_cm95_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN5 (XI0_I1548_acon I0_cm97_1 XI0_I1548_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1548_MN2 (XI0_I1548_an1 I0_cm96_1 XI0_I1548_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN1 (VSS I0_cm95_1 XI0_I1548_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN3 (XI0_I1548_an2 I0_cm95_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN4 (VSS I0_cm96_1 XI0_I1548_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1548_MN27 (I0_cm187_2 XI0_I1548_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1548_MN7 (XI0_I1548_an3 I0_cm96_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1548_MN8 (VSS I0_cm97_1 XI0_I1548_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN34 (XI0_I1429_bn3 XI0_I1429_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN35 (VSS I0_pp15_1 XI0_I1429_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN36 (XI0_I1429_bn3 I0_cm64_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN37 (XI0_I1429_bsn XI0_I1429_bcon XI0_I1429_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN40 (XI0_I1429_bn5 I0_cm64_2 XI0_I1429_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN39 (XI0_I1429_bn4 I0_pp15_1 XI0_I1429_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN39_1 (XI0_I1429_bn5 I0_pp15_1 XI0_I1429_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN40_1 (XI0_I1429_bsn I0_cm64_2 XI0_I1429_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1429_MN53 (VSS XI0_I1429_bsn I0_cm68_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1429_MN29 (XI0_I1429_bn1 XI0_I1429_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN30 (XI0_I1429_bcon I0_pp15_1 XI0_I1429_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN33 (XI0_I1429_bn2 I0_cm64_2 XI0_I1429_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN31 (VSS XI0_I1429_s1 XI0_I1429_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN32 (XI0_I1429_bn2 I0_pp15_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1429_MN55 (VSS XI0_I1429_bcon I0_cm68_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1429_MN38 (XI0_I1429_bn4 XI0_I1429_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1429_MN38_1 (VSS XI0_I1429_s1 XI0_I1429_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1429_MN25 (VSS XI0_I1429_asn XI0_I1429_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1429_MN10 (VSS I0_pp12_7 XI0_I1429_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN6 (XI0_I1429_an3 I0_pp12_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN9 (XI0_I1429_asn XI0_I1429_acon XI0_I1429_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN12 (XI0_I1429_an5 I0_pp14_3 XI0_I1429_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN11 (XI0_I1429_an4 I0_pp13_5 XI0_I1429_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1429_MN11_1 (XI0_I1429_an5 I0_pp13_5 XI0_I1429_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1429_MN12_1 (XI0_I1429_asn I0_pp14_3 XI0_I1429_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1429_MN10_1 (XI0_I1429_an4 I0_pp12_7 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN5 (XI0_I1429_acon I0_pp14_3 XI0_I1429_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1429_MN2 (XI0_I1429_an1 I0_pp13_5 XI0_I1429_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN1 (VSS I0_pp12_7 XI0_I1429_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN3 (XI0_I1429_an2 I0_pp12_7 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN4 (VSS I0_pp13_5 XI0_I1429_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1429_MN27 (I0_cm68_2 XI0_I1429_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1429_MN7 (XI0_I1429_an3 I0_pp13_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1429_MN8 (VSS I0_pp14_3 XI0_I1429_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN34 (XI0_I1433_bn3 XI0_I1433_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN35 (VSS I0_pp15_2 XI0_I1433_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN36 (XI0_I1433_bn3 I0_cm68_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN37 (XI0_I1433_bsn XI0_I1433_bcon XI0_I1433_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN40 (XI0_I1433_bn5 I0_cm68_2 XI0_I1433_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN39 (XI0_I1433_bn4 I0_pp15_2 XI0_I1433_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN39_1 (XI0_I1433_bn5 I0_pp15_2 XI0_I1433_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN40_1 (XI0_I1433_bsn I0_cm68_2 XI0_I1433_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1433_MN53 (VSS XI0_I1433_bsn I0_cm72_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1433_MN29 (XI0_I1433_bn1 XI0_I1433_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN30 (XI0_I1433_bcon I0_pp15_2 XI0_I1433_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN33 (XI0_I1433_bn2 I0_cm68_2 XI0_I1433_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN31 (VSS XI0_I1433_s1 XI0_I1433_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN32 (XI0_I1433_bn2 I0_pp15_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1433_MN55 (VSS XI0_I1433_bcon I0_cm72_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1433_MN38 (XI0_I1433_bn4 XI0_I1433_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1433_MN38_1 (VSS XI0_I1433_s1 XI0_I1433_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1433_MN25 (VSS XI0_I1433_asn XI0_I1433_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1433_MN10 (VSS I0_pp12_8 XI0_I1433_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN6 (XI0_I1433_an3 I0_pp12_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN9 (XI0_I1433_asn XI0_I1433_acon XI0_I1433_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN12 (XI0_I1433_an5 I0_pp14_4 XI0_I1433_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN11 (XI0_I1433_an4 I0_pp13_6 XI0_I1433_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1433_MN11_1 (XI0_I1433_an5 I0_pp13_6 XI0_I1433_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1433_MN12_1 (XI0_I1433_asn I0_pp14_4 XI0_I1433_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1433_MN10_1 (XI0_I1433_an4 I0_pp12_8 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN5 (XI0_I1433_acon I0_pp14_4 XI0_I1433_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1433_MN2 (XI0_I1433_an1 I0_pp13_6 XI0_I1433_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN1 (VSS I0_pp12_8 XI0_I1433_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN3 (XI0_I1433_an2 I0_pp12_8 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN4 (VSS I0_pp13_6 XI0_I1433_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1433_MN27 (I0_cm72_2 XI0_I1433_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1433_MN7 (XI0_I1433_an3 I0_pp13_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1433_MN8 (VSS I0_pp14_4 XI0_I1433_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN34 (XI0_I1461_bn3 XI0_I1461_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN35 (VSS I0_pp14_12 XI0_I1461_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN36 (XI0_I1461_bn3 I0_cm97_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN37 (XI0_I1461_bsn XI0_I1461_bcon XI0_I1461_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN40 (XI0_I1461_bn5 I0_cm97_2 XI0_I1461_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN39 (XI0_I1461_bn4 I0_pp14_12 XI0_I1461_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN39_1 (XI0_I1461_bn5 I0_pp14_12 XI0_I1461_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN40_1 (XI0_I1461_bsn I0_cm97_2 XI0_I1461_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1461_MN53 (VSS XI0_I1461_bsn I0_cm100_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1461_MN29 (XI0_I1461_bn1 XI0_I1461_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN30 (XI0_I1461_bcon I0_pp14_12 XI0_I1461_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN33 (XI0_I1461_bn2 I0_cm97_2 XI0_I1461_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN31 (VSS XI0_I1461_s1 XI0_I1461_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN32 (XI0_I1461_bn2 I0_pp14_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1461_MN55 (VSS XI0_I1461_bcon I0_cm100_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1461_MN38 (XI0_I1461_bn4 XI0_I1461_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1461_MN38_1 (VSS XI0_I1461_s1 XI0_I1461_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1461_MN25 (VSS XI0_I1461_asn XI0_I1461_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1461_MN10 (VSS I0_pp11_18 XI0_I1461_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN6 (XI0_I1461_an3 I0_pp11_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN9 (XI0_I1461_asn XI0_I1461_acon XI0_I1461_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN12 (XI0_I1461_an5 I0_pp13_14 XI0_I1461_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN11 (XI0_I1461_an4 I0_pp12_16 XI0_I1461_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1461_MN11_1 (XI0_I1461_an5 I0_pp12_16 XI0_I1461_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1461_MN12_1 (XI0_I1461_asn I0_pp13_14 XI0_I1461_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1461_MN10_1 (XI0_I1461_an4 I0_pp11_18 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN5 (XI0_I1461_acon I0_pp13_14 XI0_I1461_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1461_MN2 (XI0_I1461_an1 I0_pp12_16 XI0_I1461_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN1 (VSS I0_pp11_18 XI0_I1461_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN3 (XI0_I1461_an2 I0_pp11_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN4 (VSS I0_pp12_16 XI0_I1461_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1461_MN27 (I0_cm100_2 XI0_I1461_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1461_MN7 (XI0_I1461_an3 I0_pp12_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1461_MN8 (VSS I0_pp13_14 XI0_I1461_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN34 (XI0_I1550_bn3 XI0_I1550_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN35 (VSS I0_cm101_0 XI0_I1550_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN36 (XI0_I1550_bn3 I0_cm187_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN37 (XI0_I1550_bsn XI0_I1550_bcon XI0_I1550_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN40 (XI0_I1550_bn5 I0_cm187_2 XI0_I1550_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN39 (XI0_I1550_bn4 I0_cm101_0 XI0_I1550_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN39_1 (XI0_I1550_bn5 I0_cm101_0 XI0_I1550_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN40_1 (XI0_I1550_bsn I0_cm187_2 XI0_I1550_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1550_MN53 (VSS XI0_I1550_bsn I0_cm189_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1550_MN29 (XI0_I1550_bn1 XI0_I1550_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN30 (XI0_I1550_bcon I0_cm101_0 XI0_I1550_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN33 (XI0_I1550_bn2 I0_cm187_2 XI0_I1550_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN31 (VSS XI0_I1550_s1 XI0_I1550_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN32 (XI0_I1550_bn2 I0_cm101_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1550_MN55 (VSS XI0_I1550_bcon I0_cm189_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1550_MN38 (XI0_I1550_bn4 XI0_I1550_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1550_MN38_1 (VSS XI0_I1550_s1 XI0_I1550_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1550_MN25 (VSS XI0_I1550_asn XI0_I1550_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1550_MN10 (VSS I0_cm98_1 XI0_I1550_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN6 (XI0_I1550_an3 I0_cm98_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN9 (XI0_I1550_asn XI0_I1550_acon XI0_I1550_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN12 (XI0_I1550_an5 I0_cm100_1 XI0_I1550_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN11 (XI0_I1550_an4 I0_cm99_1 XI0_I1550_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1550_MN11_1 (XI0_I1550_an5 I0_cm99_1 XI0_I1550_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1550_MN12_1 (XI0_I1550_asn I0_cm100_1 XI0_I1550_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1550_MN10_1 (XI0_I1550_an4 I0_cm98_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN5 (XI0_I1550_acon I0_cm100_1 XI0_I1550_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1550_MN2 (XI0_I1550_an1 I0_cm99_1 XI0_I1550_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN1 (VSS I0_cm98_1 XI0_I1550_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN3 (XI0_I1550_an2 I0_cm98_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN4 (VSS I0_cm99_1 XI0_I1550_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1550_MN27 (I0_cm189_2 XI0_I1550_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1550_MN7 (XI0_I1550_an3 I0_cm99_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1550_MN8 (VSS I0_cm100_1 XI0_I1550_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN34 (XI0_I1595_bn3 XI0_I1595_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN35 (VSS I0_fa188_0 XI0_I1595_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN36 (XI0_I1595_bn3 I0_cm233_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN37 (XI0_I1595_bsn XI0_I1595_bcon XI0_I1595_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN40 (XI0_I1595_bn5 I0_cm233_2 XI0_I1595_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN39 (XI0_I1595_bn4 I0_fa188_0 XI0_I1595_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN39_1 (XI0_I1595_bn5 I0_fa188_0 XI0_I1595_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN40_1 (XI0_I1595_bsn I0_cm233_2 XI0_I1595_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1595_MN53 (VSS XI0_I1595_bsn I0_cm234_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1595_MN29 (XI0_I1595_bn1 XI0_I1595_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN30 (XI0_I1595_bcon I0_fa188_0 XI0_I1595_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN33 (XI0_I1595_bn2 I0_cm233_2 XI0_I1595_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN31 (VSS XI0_I1595_s1 XI0_I1595_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN32 (XI0_I1595_bn2 I0_fa188_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1595_MN55 (VSS XI0_I1595_bcon I0_cm234_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1595_MN38 (XI0_I1595_bn4 XI0_I1595_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1595_MN38_1 (VSS XI0_I1595_s1 XI0_I1595_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1595_MN25 (VSS XI0_I1595_asn XI0_I1595_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1595_MN10 (VSS I0_cm185_1 XI0_I1595_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN6 (XI0_I1595_an3 I0_cm185_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN9 (XI0_I1595_asn XI0_I1595_acon XI0_I1595_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN12 (XI0_I1595_an5 I0_cm187_0 XI0_I1595_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN11 (XI0_I1595_an4 I0_fa186_1 XI0_I1595_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1595_MN11_1 (XI0_I1595_an5 I0_fa186_1 XI0_I1595_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1595_MN12_1 (XI0_I1595_asn I0_cm187_0 XI0_I1595_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1595_MN10_1 (XI0_I1595_an4 I0_cm185_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN5 (XI0_I1595_acon I0_cm187_0 XI0_I1595_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1595_MN2 (XI0_I1595_an1 I0_fa186_1 XI0_I1595_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN1 (VSS I0_cm185_1 XI0_I1595_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN3 (XI0_I1595_an2 I0_cm185_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN4 (VSS I0_fa186_1 XI0_I1595_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1595_MN27 (I0_cm234_2 XI0_I1595_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1595_MN7 (XI0_I1595_an3 I0_fa186_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1595_MN8 (VSS I0_cm187_0 XI0_I1595_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN34 (XI0_I1596_bn3 XI0_I1596_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN35 (VSS I0_cm102_0 XI0_I1596_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN36 (XI0_I1596_bn3 I0_cm234_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN37 (XI0_I1596_bsn XI0_I1596_bcon XI0_I1596_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN40 (XI0_I1596_bn5 I0_cm234_2 XI0_I1596_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN39 (XI0_I1596_bn4 I0_cm102_0 XI0_I1596_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN39_1 (XI0_I1596_bn5 I0_cm102_0 XI0_I1596_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN40_1 (XI0_I1596_bsn I0_cm234_2 XI0_I1596_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1596_MN53 (VSS XI0_I1596_bsn I0_cm235_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1596_MN29 (XI0_I1596_bn1 XI0_I1596_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN30 (XI0_I1596_bcon I0_cm102_0 XI0_I1596_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN33 (XI0_I1596_bn2 I0_cm234_2 XI0_I1596_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN31 (VSS XI0_I1596_s1 XI0_I1596_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN32 (XI0_I1596_bn2 I0_cm102_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1596_MN55 (VSS XI0_I1596_bcon I0_cm235_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1596_MN38 (XI0_I1596_bn4 XI0_I1596_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1596_MN38_1 (VSS XI0_I1596_s1 XI0_I1596_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1596_MN25 (VSS XI0_I1596_asn XI0_I1596_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1596_MN10 (VSS I0_cm187_1 XI0_I1596_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN6 (XI0_I1596_an3 I0_cm187_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN9 (XI0_I1596_asn XI0_I1596_acon XI0_I1596_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN12 (XI0_I1596_an5 I0_cm189_0 XI0_I1596_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN11 (XI0_I1596_an4 I0_fa188_1 XI0_I1596_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1596_MN11_1 (XI0_I1596_an5 I0_fa188_1 XI0_I1596_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1596_MN12_1 (XI0_I1596_asn I0_cm189_0 XI0_I1596_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1596_MN10_1 (XI0_I1596_an4 I0_cm187_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN5 (XI0_I1596_acon I0_cm189_0 XI0_I1596_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1596_MN2 (XI0_I1596_an1 I0_fa188_1 XI0_I1596_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN1 (VSS I0_cm187_1 XI0_I1596_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN3 (XI0_I1596_an2 I0_cm187_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN4 (VSS I0_fa188_1 XI0_I1596_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1596_MN27 (I0_cm235_2 XI0_I1596_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1596_MN7 (XI0_I1596_an3 I0_fa188_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1596_MN8 (VSS I0_cm189_0 XI0_I1596_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN34 (XI0_I1463_bn3 XI0_I1463_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN35 (VSS I0_pp11_19 XI0_I1463_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN36 (XI0_I1463_bn3 I0_cm99_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN37 (XI0_I1463_bsn XI0_I1463_bcon XI0_I1463_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN40 (XI0_I1463_bn5 I0_cm99_2 XI0_I1463_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN39 (XI0_I1463_bn4 I0_pp11_19 XI0_I1463_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN39_1 (XI0_I1463_bn5 I0_pp11_19 XI0_I1463_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN40_1 (XI0_I1463_bsn I0_cm99_2 XI0_I1463_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1463_MN53 (VSS XI0_I1463_bsn I0_cm102_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1463_MN29 (XI0_I1463_bn1 XI0_I1463_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN30 (XI0_I1463_bcon I0_pp11_19 XI0_I1463_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN33 (XI0_I1463_bn2 I0_cm99_2 XI0_I1463_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN31 (VSS XI0_I1463_s1 XI0_I1463_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN32 (XI0_I1463_bn2 I0_pp11_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1463_MN55 (VSS XI0_I1463_bcon I0_cm102_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1463_MN38 (XI0_I1463_bn4 XI0_I1463_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1463_MN38_1 (VSS XI0_I1463_s1 XI0_I1463_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1463_MN25 (VSS XI0_I1463_asn XI0_I1463_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1463_MN10 (VSS I0_pp8_25 XI0_I1463_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN6 (XI0_I1463_an3 I0_pp8_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN9 (XI0_I1463_asn XI0_I1463_acon XI0_I1463_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN12 (XI0_I1463_an5 I0_pp10_21 XI0_I1463_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN11 (XI0_I1463_an4 I0_pp9_23 XI0_I1463_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1463_MN11_1 (XI0_I1463_an5 I0_pp9_23 XI0_I1463_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1463_MN12_1 (XI0_I1463_asn I0_pp10_21 XI0_I1463_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1463_MN10_1 (XI0_I1463_an4 I0_pp8_25 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN5 (XI0_I1463_acon I0_pp10_21 XI0_I1463_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1463_MN2 (XI0_I1463_an1 I0_pp9_23 XI0_I1463_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN1 (VSS I0_pp8_25 XI0_I1463_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN3 (XI0_I1463_an2 I0_pp8_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN4 (VSS I0_pp9_23 XI0_I1463_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1463_MN27 (I0_cm102_2 XI0_I1463_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1463_MN7 (XI0_I1463_an3 I0_pp9_23 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1463_MN8 (VSS I0_pp10_21 XI0_I1463_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN34 (XI0_I1464_bn3 XI0_I1464_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN35 (VSS I0_pp15_11 XI0_I1464_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN36 (XI0_I1464_bn3 I0_cm100_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN37 (XI0_I1464_bsn XI0_I1464_bcon XI0_I1464_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN40 (XI0_I1464_bn5 I0_cm100_2 XI0_I1464_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN39 (XI0_I1464_bn4 I0_pp15_11 XI0_I1464_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN39_1 (XI0_I1464_bn5 I0_pp15_11 XI0_I1464_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN40_1 (XI0_I1464_bsn I0_cm100_2 XI0_I1464_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1464_MN53 (VSS XI0_I1464_bsn I0_cm103_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1464_MN29 (XI0_I1464_bn1 XI0_I1464_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN30 (XI0_I1464_bcon I0_pp15_11 XI0_I1464_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN33 (XI0_I1464_bn2 I0_cm100_2 XI0_I1464_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN31 (VSS XI0_I1464_s1 XI0_I1464_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN32 (XI0_I1464_bn2 I0_pp15_11 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1464_MN55 (VSS XI0_I1464_bcon I0_cm103_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1464_MN38 (XI0_I1464_bn4 XI0_I1464_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1464_MN38_1 (VSS XI0_I1464_s1 XI0_I1464_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1464_MN25 (VSS XI0_I1464_asn XI0_I1464_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1464_MN10 (VSS I0_pp12_17 XI0_I1464_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN6 (XI0_I1464_an3 I0_pp12_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN9 (XI0_I1464_asn XI0_I1464_acon XI0_I1464_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN12 (XI0_I1464_an5 I0_pp14_13 XI0_I1464_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN11 (XI0_I1464_an4 I0_pp13_15 XI0_I1464_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1464_MN11_1 (XI0_I1464_an5 I0_pp13_15 XI0_I1464_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1464_MN12_1 (XI0_I1464_asn I0_pp14_13 XI0_I1464_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1464_MN10_1 (XI0_I1464_an4 I0_pp12_17 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN5 (XI0_I1464_acon I0_pp14_13 XI0_I1464_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1464_MN2 (XI0_I1464_an1 I0_pp13_15 XI0_I1464_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN1 (VSS I0_pp12_17 XI0_I1464_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN3 (XI0_I1464_an2 I0_pp12_17 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN4 (VSS I0_pp13_15 XI0_I1464_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1464_MN27 (I0_cm103_2 XI0_I1464_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1464_MN7 (XI0_I1464_an3 I0_pp13_15 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1464_MN8 (VSS I0_pp14_13 XI0_I1464_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN34 (XI0_I1597_bn3 XI0_I1597_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN35 (VSS I0_cm106_0 XI0_I1597_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN36 (XI0_I1597_bn3 I0_cm235_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN37 (XI0_I1597_bsn XI0_I1597_bcon XI0_I1597_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN40 (XI0_I1597_bn5 I0_cm235_2 XI0_I1597_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN39 (XI0_I1597_bn4 I0_cm106_0 XI0_I1597_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN39_1 (XI0_I1597_bn5 I0_cm106_0 XI0_I1597_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN40_1 (XI0_I1597_bsn I0_cm235_2 XI0_I1597_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1597_MN53 (VSS XI0_I1597_bsn I0_cm236_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1597_MN29 (XI0_I1597_bn1 XI0_I1597_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN30 (XI0_I1597_bcon I0_cm106_0 XI0_I1597_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN33 (XI0_I1597_bn2 I0_cm235_2 XI0_I1597_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN31 (VSS XI0_I1597_s1 XI0_I1597_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN32 (XI0_I1597_bn2 I0_cm106_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1597_MN55 (VSS XI0_I1597_bcon I0_cm236_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1597_MN38 (XI0_I1597_bn4 XI0_I1597_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1597_MN38_1 (VSS XI0_I1597_s1 XI0_I1597_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1597_MN25 (VSS XI0_I1597_asn XI0_I1597_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1597_MN10 (VSS I0_cm189_1 XI0_I1597_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN6 (XI0_I1597_an3 I0_cm189_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN9 (XI0_I1597_asn XI0_I1597_acon XI0_I1597_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN12 (XI0_I1597_an5 I0_cm105_0 XI0_I1597_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN11 (XI0_I1597_an4 I0_cm190_0 XI0_I1597_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1597_MN11_1 (XI0_I1597_an5 I0_cm190_0 XI0_I1597_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1597_MN12_1 (XI0_I1597_asn I0_cm105_0 XI0_I1597_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1597_MN10_1 (XI0_I1597_an4 I0_cm189_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN5 (XI0_I1597_acon I0_cm105_0 XI0_I1597_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1597_MN2 (XI0_I1597_an1 I0_cm190_0 XI0_I1597_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN1 (VSS I0_cm189_1 XI0_I1597_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN3 (XI0_I1597_an2 I0_cm189_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN4 (VSS I0_cm190_0 XI0_I1597_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1597_MN27 (I0_cm236_2 XI0_I1597_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1597_MN7 (XI0_I1597_an3 I0_cm190_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1597_MN8 (VSS I0_cm105_0 XI0_I1597_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN34 (XI0_I1551_bn3 XI0_I1551_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN35 (VSS I0_cm104_0 XI0_I1551_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN36 (XI0_I1551_bn3 I0_cm189_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN37 (XI0_I1551_bsn XI0_I1551_bcon XI0_I1551_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN40 (XI0_I1551_bn5 I0_cm189_2 XI0_I1551_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN39 (XI0_I1551_bn4 I0_cm104_0 XI0_I1551_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN39_1 (XI0_I1551_bn5 I0_cm104_0 XI0_I1551_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN40_1 (XI0_I1551_bsn I0_cm189_2 XI0_I1551_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1551_MN53 (VSS XI0_I1551_bsn I0_cm190_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1551_MN29 (XI0_I1551_bn1 XI0_I1551_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN30 (XI0_I1551_bcon I0_cm104_0 XI0_I1551_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN33 (XI0_I1551_bn2 I0_cm189_2 XI0_I1551_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN31 (VSS XI0_I1551_s1 XI0_I1551_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN32 (XI0_I1551_bn2 I0_cm104_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1551_MN55 (VSS XI0_I1551_bcon I0_cm190_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1551_MN38 (XI0_I1551_bn4 XI0_I1551_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1551_MN38_1 (VSS XI0_I1551_s1 XI0_I1551_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1551_MN25 (VSS XI0_I1551_asn XI0_I1551_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1551_MN10 (VSS I0_cm101_1 XI0_I1551_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN6 (XI0_I1551_an3 I0_cm101_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN9 (XI0_I1551_asn XI0_I1551_acon XI0_I1551_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN12 (XI0_I1551_an5 I0_cm103_1 XI0_I1551_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN11 (XI0_I1551_an4 I0_cm102_1 XI0_I1551_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1551_MN11_1 (XI0_I1551_an5 I0_cm102_1 XI0_I1551_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1551_MN12_1 (XI0_I1551_asn I0_cm103_1 XI0_I1551_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1551_MN10_1 (XI0_I1551_an4 I0_cm101_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN5 (XI0_I1551_acon I0_cm103_1 XI0_I1551_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1551_MN2 (XI0_I1551_an1 I0_cm102_1 XI0_I1551_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN1 (VSS I0_cm101_1 XI0_I1551_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN3 (XI0_I1551_an2 I0_cm101_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN4 (VSS I0_cm102_1 XI0_I1551_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1551_MN27 (I0_cm190_2 XI0_I1551_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1551_MN7 (XI0_I1551_an3 I0_cm102_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1551_MN8 (VSS I0_cm103_1 XI0_I1551_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN34 (XI0_I1425_bn3 XI0_I1425_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN35 (VSS I0_pp15_0 XI0_I1425_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN36 (XI0_I1425_bn3 I0_B_31_b3_5 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN37 (XI0_I1425_bsn XI0_I1425_bcon XI0_I1425_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN40 (XI0_I1425_bn5 I0_B_31_b3_5 XI0_I1425_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN39 (XI0_I1425_bn4 I0_pp15_0 XI0_I1425_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN39_1 (XI0_I1425_bn5 I0_pp15_0 XI0_I1425_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN40_1 (XI0_I1425_bsn I0_B_31_b3_5 XI0_I1425_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1425_MN53 (VSS XI0_I1425_bsn I0_cm64_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1425_MN29 (XI0_I1425_bn1 XI0_I1425_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN30 (XI0_I1425_bcon I0_pp15_0 XI0_I1425_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN33 (XI0_I1425_bn2 I0_B_31_b3_5 XI0_I1425_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN31 (VSS XI0_I1425_s1 XI0_I1425_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN32 (XI0_I1425_bn2 I0_pp15_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1425_MN55 (VSS XI0_I1425_bcon I0_cm64_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1425_MN38 (XI0_I1425_bn4 XI0_I1425_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1425_MN38_1 (VSS XI0_I1425_s1 XI0_I1425_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1425_MN25 (VSS XI0_I1425_asn XI0_I1425_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1425_MN10 (VSS I0_pp12_6 XI0_I1425_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN6 (XI0_I1425_an3 I0_pp12_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN9 (XI0_I1425_asn XI0_I1425_acon XI0_I1425_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN12 (XI0_I1425_an5 I0_pp14_2 XI0_I1425_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN11 (XI0_I1425_an4 I0_pp13_4 XI0_I1425_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1425_MN11_1 (XI0_I1425_an5 I0_pp13_4 XI0_I1425_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1425_MN12_1 (XI0_I1425_asn I0_pp14_2 XI0_I1425_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1425_MN10_1 (XI0_I1425_an4 I0_pp12_6 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN5 (XI0_I1425_acon I0_pp14_2 XI0_I1425_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1425_MN2 (XI0_I1425_an1 I0_pp13_4 XI0_I1425_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN1 (VSS I0_pp12_6 XI0_I1425_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN3 (XI0_I1425_an2 I0_pp12_6 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN4 (VSS I0_pp13_4 XI0_I1425_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1425_MN27 (I0_cm64_2 XI0_I1425_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1425_MN7 (XI0_I1425_an3 I0_pp13_4 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1425_MN8 (VSS I0_pp14_2 XI0_I1425_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN34 (XI0_I1467_bn3 XI0_I1467_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN35 (VSS I0_pp15_12 XI0_I1467_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN36 (XI0_I1467_bn3 I0_cm103_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN37 (XI0_I1467_bsn XI0_I1467_bcon XI0_I1467_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN40 (XI0_I1467_bn5 I0_cm103_2 XI0_I1467_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN39 (XI0_I1467_bn4 I0_pp15_12 XI0_I1467_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN39_1 (XI0_I1467_bn5 I0_pp15_12 XI0_I1467_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN40_1 (XI0_I1467_bsn I0_cm103_2 XI0_I1467_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1467_MN53 (VSS XI0_I1467_bsn I0_cm106_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1467_MN29 (XI0_I1467_bn1 XI0_I1467_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN30 (XI0_I1467_bcon I0_pp15_12 XI0_I1467_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN33 (XI0_I1467_bn2 I0_cm103_2 XI0_I1467_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN31 (VSS XI0_I1467_s1 XI0_I1467_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN32 (XI0_I1467_bn2 I0_pp15_12 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1467_MN55 (VSS XI0_I1467_bcon I0_cm106_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1467_MN38 (XI0_I1467_bn4 XI0_I1467_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1467_MN38_1 (VSS XI0_I1467_s1 XI0_I1467_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1467_MN25 (VSS XI0_I1467_asn XI0_I1467_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1467_MN10 (VSS I0_pp12_18 XI0_I1467_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN6 (XI0_I1467_an3 I0_pp12_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN9 (XI0_I1467_asn XI0_I1467_acon XI0_I1467_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN12 (XI0_I1467_an5 I0_pp14_14 XI0_I1467_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN11 (XI0_I1467_an4 I0_pp13_16 XI0_I1467_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1467_MN11_1 (XI0_I1467_an5 I0_pp13_16 XI0_I1467_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1467_MN12_1 (XI0_I1467_asn I0_pp14_14 XI0_I1467_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1467_MN10_1 (XI0_I1467_an4 I0_pp12_18 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN5 (XI0_I1467_acon I0_pp14_14 XI0_I1467_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1467_MN2 (XI0_I1467_an1 I0_pp13_16 XI0_I1467_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN1 (VSS I0_pp12_18 XI0_I1467_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN3 (XI0_I1467_an2 I0_pp12_18 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN4 (VSS I0_pp13_16 XI0_I1467_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1467_MN27 (I0_cm106_2 XI0_I1467_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1467_MN7 (XI0_I1467_an3 I0_pp13_16 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1467_MN8 (VSS I0_pp14_14 XI0_I1467_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN34 (XI0_I1552_bn3 XI0_I1552_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN35 (VSS I0_cm107_0 XI0_I1552_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN36 (XI0_I1552_bn3 I0_cm190_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN37 (XI0_I1552_bsn XI0_I1552_bcon XI0_I1552_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN40 (XI0_I1552_bn5 I0_cm190_2 XI0_I1552_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN39 (XI0_I1552_bn4 I0_cm107_0 XI0_I1552_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN39_1 (XI0_I1552_bn5 I0_cm107_0 XI0_I1552_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN40_1 (XI0_I1552_bsn I0_cm190_2 XI0_I1552_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1552_MN53 (VSS XI0_I1552_bsn I0_cm191_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1552_MN29 (XI0_I1552_bn1 XI0_I1552_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN30 (XI0_I1552_bcon I0_cm107_0 XI0_I1552_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN33 (XI0_I1552_bn2 I0_cm190_2 XI0_I1552_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN31 (VSS XI0_I1552_s1 XI0_I1552_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN32 (XI0_I1552_bn2 I0_cm107_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1552_MN55 (VSS XI0_I1552_bcon I0_cm191_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1552_MN38 (XI0_I1552_bn4 XI0_I1552_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1552_MN38_1 (VSS XI0_I1552_s1 XI0_I1552_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1552_MN25 (VSS XI0_I1552_asn XI0_I1552_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1552_MN10 (VSS I0_cm104_1 XI0_I1552_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN6 (XI0_I1552_an3 I0_cm104_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN9 (XI0_I1552_asn XI0_I1552_acon XI0_I1552_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN12 (XI0_I1552_an5 I0_cm106_1 XI0_I1552_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN11 (XI0_I1552_an4 I0_cm105_1 XI0_I1552_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1552_MN11_1 (XI0_I1552_an5 I0_cm105_1 XI0_I1552_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1552_MN12_1 (XI0_I1552_asn I0_cm106_1 XI0_I1552_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1552_MN10_1 (XI0_I1552_an4 I0_cm104_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN5 (XI0_I1552_acon I0_cm106_1 XI0_I1552_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1552_MN2 (XI0_I1552_an1 I0_cm105_1 XI0_I1552_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN1 (VSS I0_cm104_1 XI0_I1552_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN3 (XI0_I1552_an2 I0_cm104_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN4 (VSS I0_cm105_1 XI0_I1552_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1552_MN27 (I0_cm191_2 XI0_I1552_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1552_MN7 (XI0_I1552_an3 I0_cm105_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1552_MN8 (VSS I0_cm106_1 XI0_I1552_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN34 (XI0_I1466_bn3 XI0_I1466_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN35 (VSS I0_pp11_20 XI0_I1466_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN36 (XI0_I1466_bn3 I0_cm102_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN37 (XI0_I1466_bsn XI0_I1466_bcon XI0_I1466_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN40 (XI0_I1466_bn5 I0_cm102_2 XI0_I1466_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN39 (XI0_I1466_bn4 I0_pp11_20 XI0_I1466_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN39_1 (XI0_I1466_bn5 I0_pp11_20 XI0_I1466_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN40_1 (XI0_I1466_bsn I0_cm102_2 XI0_I1466_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1466_MN53 (VSS XI0_I1466_bsn I0_cm105_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1466_MN29 (XI0_I1466_bn1 XI0_I1466_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN30 (XI0_I1466_bcon I0_pp11_20 XI0_I1466_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN33 (XI0_I1466_bn2 I0_cm102_2 XI0_I1466_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN31 (VSS XI0_I1466_s1 XI0_I1466_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN32 (XI0_I1466_bn2 I0_pp11_20 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1466_MN55 (VSS XI0_I1466_bcon I0_cm105_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1466_MN38 (XI0_I1466_bn4 XI0_I1466_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1466_MN38_1 (VSS XI0_I1466_s1 XI0_I1466_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1466_MN25 (VSS XI0_I1466_asn XI0_I1466_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1466_MN10 (VSS I0_pp8_26 XI0_I1466_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN6 (XI0_I1466_an3 I0_pp8_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN9 (XI0_I1466_asn XI0_I1466_acon XI0_I1466_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN12 (XI0_I1466_an5 I0_pp10_22 XI0_I1466_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN11 (XI0_I1466_an4 I0_pp9_24 XI0_I1466_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1466_MN11_1 (XI0_I1466_an5 I0_pp9_24 XI0_I1466_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1466_MN12_1 (XI0_I1466_asn I0_pp10_22 XI0_I1466_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1466_MN10_1 (XI0_I1466_an4 I0_pp8_26 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN5 (XI0_I1466_acon I0_pp10_22 XI0_I1466_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1466_MN2 (XI0_I1466_an1 I0_pp9_24 XI0_I1466_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN1 (VSS I0_pp8_26 XI0_I1466_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN3 (XI0_I1466_an2 I0_pp8_26 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN4 (VSS I0_pp9_24 XI0_I1466_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1466_MN27 (I0_cm105_2 XI0_I1466_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1466_MN7 (XI0_I1466_an3 I0_pp9_24 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1466_MN8 (VSS I0_pp10_22 XI0_I1466_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN34 (XI0_I1599_bn3 XI0_I1599_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN35 (VSS I0_cm111_0 XI0_I1599_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN36 (XI0_I1599_bn3 I0_fa112_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN37 (XI0_I1599_bsn XI0_I1599_bcon XI0_I1599_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN40 (XI0_I1599_bn5 I0_fa112_0 XI0_I1599_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN39 (XI0_I1599_bn4 I0_cm111_0 XI0_I1599_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN39_1 (XI0_I1599_bn5 I0_cm111_0 XI0_I1599_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN40_1 (XI0_I1599_bsn I0_fa112_0 XI0_I1599_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1599_MN53 (VSS XI0_I1599_bsn I0_cm238_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1599_MN29 (XI0_I1599_bn1 XI0_I1599_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN30 (XI0_I1599_bcon I0_cm111_0 XI0_I1599_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN33 (XI0_I1599_bn2 I0_fa112_0 XI0_I1599_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN31 (VSS XI0_I1599_s1 XI0_I1599_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN32 (XI0_I1599_bn2 I0_cm111_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1599_MN55 (VSS XI0_I1599_bcon I0_cm238_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1599_MN38 (XI0_I1599_bn4 XI0_I1599_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1599_MN38_1 (VSS XI0_I1599_s1 XI0_I1599_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1599_MN25 (VSS XI0_I1599_asn XI0_I1599_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1599_MN10 (VSS I0_cm191_1 XI0_I1599_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN6 (XI0_I1599_an3 I0_cm191_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN9 (XI0_I1599_asn XI0_I1599_acon XI0_I1599_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN12 (XI0_I1599_an5 I0_cm193_0 XI0_I1599_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN11 (XI0_I1599_an4 I0_fa192_1 XI0_I1599_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1599_MN11_1 (XI0_I1599_an5 I0_fa192_1 XI0_I1599_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1599_MN12_1 (XI0_I1599_asn I0_cm193_0 XI0_I1599_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1599_MN10_1 (XI0_I1599_an4 I0_cm191_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN5 (XI0_I1599_acon I0_cm193_0 XI0_I1599_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1599_MN2 (XI0_I1599_an1 I0_fa192_1 XI0_I1599_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN1 (VSS I0_cm191_1 XI0_I1599_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN3 (XI0_I1599_an2 I0_cm191_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN4 (VSS I0_fa192_1 XI0_I1599_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1599_MN27 (I0_cm238_2 XI0_I1599_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1599_MN7 (XI0_I1599_an3 I0_fa192_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1599_MN8 (VSS I0_cm193_0 XI0_I1599_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN34 (XI0_I1554_bn3 XI0_I1554_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN35 (VSS I0_cm110_0 XI0_I1554_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN36 (XI0_I1554_bn3 I0_cm191_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN37 (XI0_I1554_bsn XI0_I1554_bcon XI0_I1554_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN40 (XI0_I1554_bn5 I0_cm191_2 XI0_I1554_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN39 (XI0_I1554_bn4 I0_cm110_0 XI0_I1554_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN39_1 (XI0_I1554_bn5 I0_cm110_0 XI0_I1554_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN40_1 (XI0_I1554_bsn I0_cm191_2 XI0_I1554_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1554_MN53 (VSS XI0_I1554_bsn I0_cm193_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1554_MN29 (XI0_I1554_bn1 XI0_I1554_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN30 (XI0_I1554_bcon I0_cm110_0 XI0_I1554_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN33 (XI0_I1554_bn2 I0_cm191_2 XI0_I1554_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN31 (VSS XI0_I1554_s1 XI0_I1554_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN32 (XI0_I1554_bn2 I0_cm110_0 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1554_MN55 (VSS XI0_I1554_bcon I0_cm193_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1554_MN38 (XI0_I1554_bn4 XI0_I1554_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1554_MN38_1 (VSS XI0_I1554_s1 XI0_I1554_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1554_MN25 (VSS XI0_I1554_asn XI0_I1554_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1554_MN10 (VSS I0_cm107_1 XI0_I1554_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN6 (XI0_I1554_an3 I0_cm107_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN9 (XI0_I1554_asn XI0_I1554_acon XI0_I1554_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN12 (XI0_I1554_an5 I0_fa109_1 XI0_I1554_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN11 (XI0_I1554_an4 I0_cm108_1 XI0_I1554_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
    I_MXI0_I1554_MN11_1 (XI0_I1554_an5 I0_cm108_1 XI0_I1554_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.14398p pd=0.67997u ps=1.75997u
    I_MXI0_I1554_MN12_1 (XI0_I1554_asn I0_fa109_1 XI0_I1554_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1554_MN10_1 (XI0_I1554_an4 I0_cm107_1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN5 (XI0_I1554_acon I0_fa109_1 XI0_I1554_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1554_MN2 (XI0_I1554_an1 I0_cm108_1 XI0_I1554_acon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN1 (VSS I0_cm107_1 XI0_I1554_an1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN3 (XI0_I1554_an2 I0_cm107_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN4 (VSS I0_cm108_1 XI0_I1554_an2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04678p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1554_MN27 (I0_cm193_2 XI0_I1554_acon VSS VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1554_MN7 (XI0_I1554_an3 I0_cm108_1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.08158p pd=0.67997u ps=1.15997u
    I_MXI0_I1554_MN8 (VSS I0_fa109_1 XI0_I1554_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN34 (XI0_I1469_bn3 XI0_I1469_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN35 (VSS I0_pp12_19 XI0_I1469_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN36 (XI0_I1469_bn3 I0_cm105_2 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN37 (XI0_I1469_bsn XI0_I1469_bcon XI0_I1469_bn3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN40 (XI0_I1469_bn5 I0_cm105_2 XI0_I1469_bsn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN39 (XI0_I1469_bn4 I0_pp12_19 XI0_I1469_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN39_1 (XI0_I1469_bn5 I0_pp12_19 XI0_I1469_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN40_1 (XI0_I1469_bsn I0_cm105_2 XI0_I1469_bn5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.07558p as=0.04678p pd=1.15997u ps=0.67997u
    I_MXI0_I1469_MN53 (VSS XI0_I1469_bsn I0_cm108_0 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.06958p as=0.06958p pd=1.15997u ps=1.15997u
    I_MXI0_I1469_MN29 (XI0_I1469_bn1 XI0_I1469_s1 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN30 (XI0_I1469_bcon I0_pp12_19 XI0_I1469_bn1 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN33 (XI0_I1469_bn2 I0_cm105_2 XI0_I1469_bcon VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN31 (VSS XI0_I1469_s1 XI0_I1469_bn2 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN32 (XI0_I1469_bn2 I0_pp12_19 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.08158p as=0.05278p pd=1.15997u ps=0.67997u
    I_MXI0_I1469_MN55 (VSS XI0_I1469_bcon I0_cm108_1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04378p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1469_MN38 (XI0_I1469_bn4 XI0_I1469_s1 VSS VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.09538p as=0.04378p pd=1.21997u ps=0.67997u
    I_MXI0_I1469_MN38_1 (VSS XI0_I1469_s1 XI0_I1469_bn4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.09538p pd=0.67997u ps=1.21997u
    I_MXI0_I1469_MN25 (VSS XI0_I1469_asn XI0_I1469_s1 VSS) gpdk090_nmos1v w=0.12u l=0.1u ad=0.04678p as=0.06958p pd=0.67997u ps=1.15997u
    I_MXI0_I1469_MN10 (VSS I0_pp9_25 XI0_I1469_an4 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04978p as=0.04678p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN6 (XI0_I1469_an3 I0_pp9_25 VSS VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.05278p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN9 (XI0_I1469_asn XI0_I1469_acon XI0_I1469_an3 VSS) gpdk090_nmos1v w=0.24u l=0.1u ad=0.04978p as=0.05278p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN12 (XI0_I1469_an5 I0_pp11_21 XI0_I1469_asn VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.04678p as=0.04978p pd=0.67997u ps=0.67997u
    I_MXI0_I1469_MN11 (XI0_I1469_an4 I0_pp10_23 XI0_I1469_an5 VSS) gpdk090_nmos1v w=0.18u l=0.1u ad=0.14398p as=0.04678p pd=1.75997u ps=0.67997u
